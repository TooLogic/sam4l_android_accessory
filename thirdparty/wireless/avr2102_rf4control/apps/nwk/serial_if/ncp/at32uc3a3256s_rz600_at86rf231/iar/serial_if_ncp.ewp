# IAR project serial_if_ncp.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: ENABLE_STACK_NVM; UDD_ENABLE; SAL_TYPE=AT86RF2xx; NLDE_HANDLE; DISABLE_TSTAMP_IRQ=1; TAL_TYPE=AT86RF231; DEBUG=0; MAC_USER_BUILD_CONFIG; ENABLE_TRX_SRAM; RF4CE_SECURITY; RSSI_TO_LQI_MAPPING; BOARD=RZ600; PAL_USE_SPI_TRX=1; STB_ON_SAL; REDUCED_PARAM_CHECK; EXTERN_EEPROM_AVAILABLE=0; CHANNEL_AGILITY; PRIVATE_NIB; SIO_HUB; RF4CE_CALLBACK_PARAM; HIGHEST_STACK_LAYER=RF4CE; RF4CE_PLATFORM
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ..; ../../../../../../../avr2025_mac/source/mac/inc; ../../../../../../addons/serial_interface; ../../../../../../../../../common/services/usb/class/cdc/device; ../../../../../../../../../avr32/drivers/pm; ../../../../../../../../../avr32/boards; ../../../../../../../../../common/services/spi/uc3_spi; ../../../../../../../avr2025_mac/source/pal/common_sw_timer; ../../../../../../../../../common/drivers/nvm; ../../../../../../../../../avr32/drivers/usbb; ../../../../../../include; ../../../../../../../avr2025_mac/source/resources/queue/inc; ../../../../../../../avr2025_mac/include; ../../../../../../../avr2025_mac/source/stb/inc; ../../../../../../../avr2025_mac/source/sal/inc; ../../../../../../../avr2025_mac/source/pal/common_hw_timer/uc3; ../../../../../../../../../avr32/drivers/tc; ../../../../../../../addons/sio2host/usb; ../../../../../../../../../common/utils/stdio/stdio_usb; ../../../../../../../../../avr32/utils; ../../../../../../../../../avr32/drivers/gpio; ../../../../../../../avr2025_mac/source/resources/buffer/inc; ../../../../../../../../../common/utils; ../../../../../../../../../avr32/boards/rz600; ../../../../../../../../../avr32/drivers/spi; ../../../../../../../../../common/services/usb/class/cdc; ../..; ../../../../../../../../../common/services/clock; ../../..; ../../../../../../../../../common/services/sleepmgr; ../../../../../../../../../common/services/usb; ../../../../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../../avr2025_mac/source/tal/inc; ../../../../../../../avr2025_mac/source/pal; ../../../../../../lib/nwk/config; ../../../../../../../avr2025_mac/source/pal/common_hw_timer; ../../../../../../../../../common/services/delay; ../../../../../../../../../common/services/usb/udc; ../../../../../../../../../common/services/spi; ../../../../../../../../../common/boards; ../../../../../../../../../avr32/drivers/flashc; ../../../../../../../../../common/services/ioport; ../../../../../../../../../avr32/utils/preprocessor; ../../../../../../../avr2025_mac/source/tal/at86rf231/inc; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../avr32/utils/linker_scripts/at32uc3a3/256s/iar/lnkuc3a3256s.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/wireless/avr2102_rf4control/lib/nwk/at32uc3a3256s/iar
    ../../../../../../lib/nwk/at32uc3a3256s/iar/: librf4ce-nwk.r82
  group thirdparty/wireless/avr2102_rf4control/apps/nwk/serial_if
    ../../../: main.c
  group thirdparty/wireless/avr2102_rf4control/addons/serial_interface
    ../../../../../../addons/serial_interface/: serial_interface.c
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../../../avr2025_mac/source/pal/: pal_ext_trx.c pal.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/uc3
    ../../../../../../../avr2025_mac/source/pal/common_hw_timer/uc3/: hw_timer.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/uc3/lib
    ../../../../../../../avr2025_mac/source/pal/common_hw_timer/uc3/lib/: uc3_lib_hw_timer.r82
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../../../avr2025_mac/source/pal/common_sw_timer/: common_sw_timer.c
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../../../../../avr2025_mac/source/mac/src/: mac_security.c mac_poll.c mac_beacon.c mac_data_req.c mac_disassociate.c mac_pib.c mac_misc.c mac_process_tal_tx_frame_status.c mac.c mac_data_extract_mhr.c mac_rx_enable.c mac_mcps_data.c mac_process_beacon_frame.c mac_data_ind.c mac_scan.c mac_tx_coord_realignment_command.c mac_dispatcher.c mac_orphan.c mac_start.c mac_associate.c mac_sync.c
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../../../avr2025_mac/source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf231/src
    ../../../../../../../avr2025_mac/source/tal/at86rf231/src/: tal_pib.c tal_slotted_csma.c tal_init.c tal_rx_enable.c tal.c tal_pwr_mgmt.c tal_tx.c tal_rx.c tal_ed.c tal_irq_handler.c
  group thirdparty/wireless/avr2025_mac/source/stb/src
    ../../../../../../../avr2025_mac/source/stb/src/: stb.c stb_help.c stb_armcrypto.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../../../avr2025_mac/source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../../../avr2025_mac/source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/sal/at86rf2xx/src
    ../../../../../../../avr2025_mac/source/sal/at86rf2xx/src/: sal.c
  group thirdparty/wireless/addons/sio2host/usb
    ../../../../../../../addons/sio2host/usb/: sio2host.c
  group common/utils/stdio
    ../../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_usb
    ../../../../../../../../../common/utils/stdio/stdio_usb/: stdio_usb.c
  group common/services/spi/uc3_spi
    ../../../../../../../../../common/services/spi/uc3_spi/: spi_master.c
  group common/services/clock/uc3a3_a4
    ../../../../../../../../../common/services/clock/uc3a3_a4/: sysclk.c
  group common/services/usb/class/cdc/device
    ../../../../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c
  group common/services/usb/udc
    ../../../../../../../../../common/services/usb/udc/: udc.c
  group common/services/sleepmgr/uc3
    ../../../../../../../../../common/services/sleepmgr/uc3/: sleepmgr.c
  group common/drivers/nvm/uc3
    ../../../../../../../../../common/drivers/nvm/uc3/: uc3_nvm.c
  group avr32/drivers/pm
    ../../../../../../../../../avr32/drivers/pm/: power_clocks_lib.c pm.c pm_conf_clocks.c
  group avr32/drivers/spi
    ../../../../../../../../../avr32/drivers/spi/: spi.c
  group avr32/drivers/gpio
    ../../../../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/tc
    ../../../../../../../../../avr32/drivers/tc/: tc.c
  group avr32/drivers/flashc
    ../../../../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/usbb
    ../../../../../../../../../avr32/drivers/usbb/: usbb_device.c
  group avr32/boards/rz600
    ../../../../../../../../../avr32/boards/rz600/: led.c init.c
  group avr32/utils/startup
    ../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82
