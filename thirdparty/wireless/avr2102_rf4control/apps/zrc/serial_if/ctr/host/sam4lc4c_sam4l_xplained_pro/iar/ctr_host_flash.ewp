# IAR project ctr_host_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ENABLE_STACK_NVM; BOARD=SAM4L_XPLAINED_PRO; NLDE_HANDLE; __SAM4LC4C__; ZRC_CMD_DISCOVERY; DEBUG=0; VENDOR_DATA; MAC_USER_BUILD_CONFIG; ENABLE_TRX_SRAM; RF4CE_SECURITY; RSSI_TO_LQI_MAPPING; PBP_REC; ARM_MATH_CM4=true; STB_ON_SAL; PBP_ORG; REDUCED_PARAM_CHECK; EXTERN_EEPROM_AVAILABLE=0; ZRC_PROFILE; CHANNEL_AGILITY; PRIVATE_NIB; RF4CE_PLATFORM; RF4CE_CALLBACK_PARAM; HIGHEST_STACK_LAYER=RF4CE; SIO_HUB
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam/utils/header_files; ../../../../../../../../avr2025_mac/source/mac/inc; ../..; ../../../../../../../../../../common/boards; ../../../../../../../addons/serial_interface; ../../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../avr2025_mac/source/pal/common_sw_timer; ../../../../../../../include; ../../../../../../../../avr2025_mac/source/resources/queue/inc; ../../../../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../../../avr2025_mac/include; ../../../../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../../../../../addons/sio2host/uart; ../../../../../../../../../../common/services/serial; ../../../../../../../addons/api_parser; ../../../../../../../../../../common/utils; ../../../../../../../../addons/sio2ncp/uart; ..; ../../../../../../../../../../sam/drivers/wdt; ../../../../../../../../../../common/services/clock; ../../../../../../../../../../sam/boards; ../../../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../../avr2025_mac/source/resources/buffer/inc; ../../../..; ../../../../../../../../avr2025_mac/source/pal; ../../../../../../../../avr2025_mac/source/pal/common_hw_timer; ../../../../../../../../../../common/services/delay; ../../../../../../../../../../sam/utils; ../../../../../../../../../../sam/drivers/tc; ../../../../../../../../../../sam/drivers/usart; ../../../../../../../../../../common/services/serial/sam_uart; ../../../../../../../../../../sam/drivers/flashcalw; ../../../../../../../../../../sam/boards/sam4l_xplained_pro; ../../../../../../../../../../common/services/ioport; ../../../../../../../../../../sam/drivers/bpm; ../../../../../../../../avr2025_mac/source/pal/common_hw_timer/sam; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ctr_host_flash.bin
  ILINK.IlinkOutputFile: ctr_host_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/sam
    ../../../../../../../../avr2025_mac/source/pal/common_hw_timer/sam/: hw_timer.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/sam/lib
    ../../../../../../../../avr2025_mac/source/pal/common_hw_timer/sam/lib/: sam4l_lib_hw_timer.a
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../../../../avr2025_mac/source/pal/common_sw_timer/: common_sw_timer.c
  group thirdparty/wireless/addons/sio2ncp/uart
    ../../../../../../../../addons/sio2ncp/uart/: sio2ncp.c
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../../../../addons/sio2host/uart/: sio2host.c
  group thirdparty/wireless/avr2102_rf4control/apps/zrc/serial_if
    ../../../../: main.c
  group thirdparty/wireless/avr2102_rf4control/addons/serial_interface
    ../../../../../../../addons/serial_interface/: serial_interface.c
  group thirdparty/wireless/avr2102_rf4control/addons/api_parser
    ../../../../../../../addons/api_parser/: api_parser.c
  group common/utils/interrupt
    ../../../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../../../../../../common/utils/stdio/: write.c read.c
  group common/services/clock/sam4l
    ../../../../../../../../../../common/services/clock/sam4l/: pll.c sysclk.c dfll.c osc.c
  group common/services/serial
    ../../../../../../../../../../common/services/serial/: usart_serial.c
  group common/services/delay/sam
    ../../../../../../../../../../common/services/delay/sam/: cycle_counter.c
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/: exceptions.c system_sam4l.c
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/drivers/tc
    ../../../../../../../../../../sam/drivers/tc/: tc.c
  group sam/drivers/flashcalw
    ../../../../../../../../../../sam/drivers/flashcalw/: flashcalw.c
  group sam/drivers/usart
    ../../../../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/wdt
    ../../../../../../../../../../sam/drivers/wdt/: wdt_sam4l.c
  group sam/drivers/bpm
    ../../../../../../../../../../sam/drivers/bpm/: bpm.c
  group sam/boards/sam4l_xplained_pro
    ../../../../../../../../../../sam/boards/sam4l_xplained_pro/: init.c
