# IAR project tgt_ncp.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x200
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m256rfr2 ATmega256RFR2
  ICCAVR.CCDefines: MAC_USER_BUILD_CONFIG; BOARD=ATMEGA256RFR2_XPLAINED_PRO; NLDE_HANDLE; ZRC_CMD_DISCOVERY; RF4CE_TARGET; DEBUG=0; VENDOR_DATA; ENABLE_STACK_NVM; ENABLE_TRX_SRAM; RF4CE_SECURITY; RSSI_TO_LQI_MAPPING; PBP_REC; STB_ON_SAL; REDUCED_PARAM_CHECK; EXTERN_EEPROM_AVAILABLE=0; SAL_TYPE=ATMEGARF_SAL; ZRC_PROFILE; TAL_TYPE=ATMEGARFR2; CHANNEL_AGILITY; PRIVATE_NIB; RF4CE_CALLBACK_PARAM; HIGHEST_STACK_LAYER=RF4CE; SIO_HUB
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../../avr2025_mac/source/mac/inc; ../../../../../../../../../../mega/utils; ../../../../../../../addons/serial_interface; ../..; ../../../../../../../../avr2025_mac/source/pal/common_sw_timer; ../../../../../../../include; ../../../../../../../../avr2025_mac/source/resources/queue/inc; ../../../../../../../../avr2025_mac/source/tal/inc; ../../../../../../../../avr2025_mac/include; ../../../../../../../../avr2025_mac/source/pal; ../../../../../../../../avr2025_mac/source/stb/inc; ../../../../../../../../avr2025_mac/source/sal/inc; ../../../../../../../../../../common/services/serial; ..; ../../../../../../../../avr2025_mac/source/resources/buffer/inc; ../../../../../../../../../../common/utils; ../../../../../../../../avr2025_mac/source/pal/mega/drivers/tc; ../../../../../../../../avr2025_mac/source/tal/atmegarfr2/inc; ../../../../../../../../avr2025_mac/source/pal/common_hw_timer/mega; ../../../../../../../../../../mega/drivers/cpu; ../../../../../../../../../../common/services/delay; ../../../../../../../../../../common/services/clock; ../../../../../../../../../../mega/boards; ../../../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../../../../common/services/serial/megarf_usart; ../../../..; ../../../../../../../../../../mega/drivers/usart; ../../../../../../../../addons/sio2host/uart; ../../../../../../../../../../common/services/gpio; ../../../../../../../../avr2025_mac/source/pal/common/drivers/nvm; ../../../../../../../../avr2025_mac/source/pal/common_hw_timer; ../../../../../../../lib/zrc/tgt/config; ../../../../../../../../avr2025_mac/source/pal/mega/drivers/flash; ../../../../../../../../../../common/boards; ../../../../../../../../../../common/services/ioport; ../../../../../../../../../../mega/boards/atmega256rfr2_xplained_pro; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
  XLINK.XclFile: ../link_iar.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; MAC_USER_BUILD_CONFIG; BOARD=ATMEGA256RFR2_XPLAINED_PRO; NLDE_HANDLE; ZRC_CMD_DISCOVERY; RF4CE_TARGET; DEBUG=0; VENDOR_DATA; ENABLE_STACK_NVM; ENABLE_TRX_SRAM; RF4CE_SECURITY; RSSI_TO_LQI_MAPPING; PBP_REC; STB_ON_SAL; REDUCED_PARAM_CHECK; EXTERN_EEPROM_AVAILABLE=0; SAL_TYPE=ATMEGARF_SAL; ZRC_PROFILE; TAL_TYPE=ATMEGARFR2; CHANNEL_AGILITY; PRIVATE_NIB; RF4CE_CALLBACK_PARAM; HIGHEST_STACK_LAYER=RF4CE; SIO_HUB
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../../../../avr2025_mac/source/pal/: pal.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/mega
    ../../../../../../../../avr2025_mac/source/pal/common_hw_timer/mega/: hw_timer.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/mega/lib
    ../../../../../../../../avr2025_mac/source/pal/common_hw_timer/mega/lib/: mega_lib_hw_timer.r90
  group thirdparty/wireless/avr2025_mac/source/pal/mega/drivers/flash
    ../../../../../../../../avr2025_mac/source/pal/mega/drivers/flash/: flash.c
  group thirdparty/wireless/avr2025_mac/source/pal/mega/drivers/tc
    ../../../../../../../../avr2025_mac/source/pal/mega/drivers/tc/: tc_megarf.c
  group thirdparty/wireless/avr2025_mac/source/pal/common/drivers/nvm/mega
    ../../../../../../../../avr2025_mac/source/pal/common/drivers/nvm/mega/: mega_nvm.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../../../../avr2025_mac/source/pal/common_sw_timer/: common_sw_timer.c
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../../../../../../avr2025_mac/source/mac/src/: mac_start.c mac_process_tal_tx_frame_status.c mac_beacon.c mac_sync.c mac_associate.c mac_process_beacon_frame.c mac_data_req.c mac_data_extract_mhr.c mac_pib.c mac_mcps_data.c mac_security.c mac_orphan.c mac_tx_coord_realignment_command.c mac_poll.c mac_data_ind.c mac_misc.c mac_rx_enable.c mac_scan.c mac_dispatcher.c mac.c mac_disassociate.c
  group thirdparty/wireless/avr2025_mac/source/stb/src
    ../../../../../../../../avr2025_mac/source/stb/src/: stb_help.c stb_armcrypto.c stb.c
  group thirdparty/wireless/avr2025_mac/source/tal/atmegarfr2/src
    ../../../../../../../../avr2025_mac/source/tal/atmegarfr2/src/: tal_ed.c tal_tx.c tal_irq_handler.c tal_rx_enable.c tal_init.c tal.c tal_pwr_mgmt.c tal_rx.c tal_slotted_csma.c tal_pib.c
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../../../../avr2025_mac/source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/sal/atmegarf_sal/src
    ../../../../../../../../avr2025_mac/source/sal/atmegarf_sal/src/: sal.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../../../../avr2025_mac/source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../../../../avr2025_mac/source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2102_rf4control/lib/zrc/tgt/atmega256rfr2/iar
    ../../../../../../../lib/zrc/tgt/atmega256rfr2/iar/: librf4ce-zrc-target.r90
  group thirdparty/wireless/avr2102_rf4control/addons/serial_interface
    ../../../../../../../addons/serial_interface/: serial_interface.c
  group thirdparty/wireless/avr2102_rf4control/apps/zrc/serial_if
    ../../../../: main.c
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../../../../addons/sio2host/uart/: sio2host.c
  group common/services/clock/mega
    ../../../../../../../../../../common/services/clock/mega/: sysclk.c
  group common/services/serial
    ../../../../../../../../../../common/services/serial/: usart_serial.c
  group common/utils/stdio
    ../../../../../../../../../../common/utils/stdio/: read.c write.c
  group mega/boards/atmega256rfr2_xplained_pro
    ../../../../../../../../../../mega/boards/atmega256rfr2_xplained_pro/: init.c
  group mega/drivers/usart
    ../../../../../../../../../../mega/drivers/usart/: usart_megarf.c
