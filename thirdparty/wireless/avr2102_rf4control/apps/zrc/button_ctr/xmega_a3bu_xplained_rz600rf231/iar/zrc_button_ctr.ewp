# IAR project zrc_button_ctr.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x200
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: ZRC_CMD_DISCOVERY; IOPORT_XMEGA_COMPAT; NLDE_HANDLE; SAL_TYPE=ATXMEGA_SAL; DISABLE_TSTAMP_IRQ=1; TAL_TYPE=AT86RF231; ENABLE_TFA; TFA_BAT_MON; VENDOR_DATA; MAC_USER_BUILD_CONFIG; ENABLE_TRX_SRAM; ENABLE_STACK_NVM; RF4CE_SECURITY; RSSI_TO_LQI_MAPPING; ENABLE_PWR_SAVE_MODE; PAL_USE_SPI_TRX=1; STB_ON_SAL; PBP_ORG; REDUCED_PARAM_CHECK; EXTERN_EEPROM_AVAILABLE=0; BOARD=XMEGA_A3BU_XPLAINED; ZRC_PROFILE; PRIVATE_NIB; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; RF4CE_CALLBACK_PARAM; HIGHEST_STACK_LAYER=RF4CE; DEBUG=0; SIO_HUB
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../avr2025_mac/source/pal/common_hw_timer/xmega; ../../../../../../../../common/services/usb/class/cdc/device; ../../../../../lib/zrc/ctr/config; ../../../../../../avr2025_mac/source/mac/inc; ../../../../../../../../xmega/boards; ../../../../../../../../xmega/drivers/pmic; ../../../../../../../../common/services/spi/xmega_spi; ../../../../../../../../xmega/drivers/tc; ../../../../../../../../xmega/utils; ../../../../../../avr2025_mac/source/tal/at86rf231/inc; ../../../../../../../../common/drivers/nvm; ../../../../../include; ../../../../../../avr2025_mac/source/resources/queue/inc; ../../../../../../avr2025_mac/include; ../../../../../../avr2025_mac/source/stb/inc; ../../../../../../avr2025_mac/source/sal/inc; ../../../../../../../../xmega/utils/preprocessor; ../../../../../../addons/sio2host/usb; ../../../../../../../../common/utils/stdio/stdio_usb; ../../../../../../avr2025_mac/source/tfa/inc; ../../../../../../../../xmega/drivers/nvm; ../../../../../../../../common/services/sleepmgr; ../../../../../../../../common/utils; ../..; ../../../../../../../../common/services/usb/class/cdc; ../../../../../../../../common/services/clock; ../../../../../../../../xmega/boards/xmega_a3bu_xplained; ../../../../../../avr2025_mac/source/resources/buffer/inc; ../../../../../../../../common/services/usb; ..; ../../../../../../../../xmega/drivers/sleep; ../../../../../../avr2025_mac/source/tal/inc; ../../../../../../avr2025_mac/source/pal; ../../../../../../../../common/services/gpio; ../../../../../../avr2025_mac/source/pal/common_hw_timer; ../../../../../../../../common/services/delay; ../../../../../../../../common/services/usb/udc; ../../../../../../../../xmega/drivers/usb; ../../../../../../../../common/services/spi; ../../../../../../../../common/boards; ../../../../../../../../xmega/drivers/spi; ../../../../../../../../common/services/ioport; ../../../../../../avr2025_mac/source/pal/common_sw_timer; ../../../../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; ZRC_CMD_DISCOVERY; IOPORT_XMEGA_COMPAT; NLDE_HANDLE; SAL_TYPE=ATXMEGA_SAL; DISABLE_TSTAMP_IRQ=1; TAL_TYPE=AT86RF231; ENABLE_TFA; TFA_BAT_MON; VENDOR_DATA; MAC_USER_BUILD_CONFIG; ENABLE_TRX_SRAM; ENABLE_STACK_NVM; RF4CE_SECURITY; RSSI_TO_LQI_MAPPING; ENABLE_PWR_SAVE_MODE; PAL_USE_SPI_TRX=1; STB_ON_SAL; PBP_ORG; REDUCED_PARAM_CHECK; EXTERN_EEPROM_AVAILABLE=0; BOARD=XMEGA_A3BU_XPLAINED; ZRC_PROFILE; PRIVATE_NIB; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; RF4CE_CALLBACK_PARAM; HIGHEST_STACK_LAYER=RF4CE; DEBUG=0; SIO_HUB
  group thirdparty/wireless/avr2102_rf4control/lib/zrc/ctr/atxmega256a3bu/iar
    ../../../../../lib/zrc/ctr/atxmega256a3bu/iar/: librf4ce-zrc-controller.r90
  group thirdparty/wireless/avr2102_rf4control/apps/zrc/button_ctr
    ../../: vendor_data.c main.c
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../../avr2025_mac/source/pal/: pal.c pal_ext_trx.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/xmega
    ../../../../../../avr2025_mac/source/pal/common_hw_timer/xmega/: hw_timer.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/xmega/lib
    ../../../../../../avr2025_mac/source/pal/common_hw_timer/xmega/lib/: xmegaa3_lib_hw_timer.r90
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../../avr2025_mac/source/pal/common_sw_timer/: common_sw_timer.c
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../../../../avr2025_mac/source/mac/src/: mac_tx_coord_realignment_command.c mac_sync.c mac_process_beacon_frame.c mac_mcps_data.c mac_beacon.c mac_security.c mac_pib.c mac_data_req.c mac_dispatcher.c mac_data_extract_mhr.c mac_process_tal_tx_frame_status.c mac_disassociate.c mac_misc.c mac_associate.c mac_orphan.c mac_start.c mac_rx_enable.c mac_scan.c mac_poll.c mac.c mac_data_ind.c
  group thirdparty/wireless/avr2025_mac/source/sal/atxmega_sal/src
    ../../../../../../avr2025_mac/source/sal/atxmega_sal/src/: sal.c
  group thirdparty/wireless/avr2025_mac/source/tfa/at86rf231/src
    ../../../../../../avr2025_mac/source/tfa/at86rf231/src/: tfa.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf231/src
    ../../../../../../avr2025_mac/source/tal/at86rf231/src/: tal_init.c tal_irq_handler.c tal_pib.c tal_tx.c tal_slotted_csma.c tal_ed.c tal.c tal_rx.c tal_rx_enable.c tal_pwr_mgmt.c
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../../avr2025_mac/source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/stb/src
    ../../../../../../avr2025_mac/source/stb/src/: stb.c stb_armcrypto.c stb_help.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../../avr2025_mac/source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../../avr2025_mac/source/resources/queue/src/: qmm.c
  group thirdparty/wireless/addons/sio2host/usb
    ../../../../../../addons/sio2host/usb/: sio2host.c
  group common/services/ioport/xmega
    ../../../../../../../../common/services/ioport/xmega/: ioport_compat.c
  group common/services/usb/class/cdc/device
    ../../../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c
  group common/services/usb/udc
    ../../../../../../../../common/services/usb/udc/: udc.c
  group common/services/clock/xmega
    ../../../../../../../../common/services/clock/xmega/: sysclk.c
  group common/services/sleepmgr/xmega
    ../../../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/spi/xmega_spi
    ../../../../../../../../common/services/spi/xmega_spi/: spi_master.c
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_usb
    ../../../../../../../../common/utils/stdio/stdio_usb/: stdio_usb.c
  group common/drivers/nvm/xmega
    ../../../../../../../../common/drivers/nvm/xmega/: xmega_nvm.c
  group xmega/drivers/spi
    ../../../../../../../../xmega/drivers/spi/: spi.c
  group xmega/drivers/tc
    ../../../../../../../../xmega/drivers/tc/: tc.c
  group xmega/drivers/usb
    ../../../../../../../../xmega/drivers/usb/: usb_device.c
  group xmega/drivers/nvm
    ../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/cpu
    ../../../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../../../../xmega/boards/xmega_a3bu_xplained/: init.c
