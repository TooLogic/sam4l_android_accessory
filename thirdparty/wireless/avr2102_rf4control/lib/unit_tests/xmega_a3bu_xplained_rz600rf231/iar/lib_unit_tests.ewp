# IAR project lib_unit_tests.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x200
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: MAC_USER_BUILD_CONFIG; IOPORT_XMEGA_COMPAT; NLDE_HANDLE; SAL_TYPE=ATXMEGA_SAL; DISABLE_TSTAMP_IRQ=1; ZRC_CMD_DISCOVERY; RF4CE_TARGET; TAL_TYPE=AT86RF231; DEBUG=0; VENDOR_DATA; ENABLE_STACK_NVM; ENABLE_TRX_SRAM; TEST_SUITE_DEFINE_ASSERT_MACRO; RF4CE_SECURITY; RSSI_TO_LQI_MAPPING; PBP_REC; PAL_USE_SPI_TRX=1; STB_ON_SAL; REDUCED_PARAM_CHECK; BOARD=XMEGA_A3BU_XPLAINED; ZRC_PROFILE; CHANNEL_AGILITY; PRIVATE_NIB; SIO_HUB; RF4CE_CALLBACK_PARAM; _ASSERT_ENABLE_; HIGHEST_STACK_LAYER=RF4CE; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../avr2025_mac/source/pal/common_hw_timer/xmega; ../../../../../../../common/services/usb/class/cdc/device; ../../../../../avr2025_mac/source/mac/inc; ../../../../../../../xmega/drivers/pmic; ../../../../../../../common/services/spi/xmega_spi; ../../../../../../../common/boards; ../../../../../../../xmega/drivers/tc; ../../../../../../../xmega/utils; ../../../../../../../common/services/usb/udc; ../../../../../avr2025_mac/source/tal/at86rf231/inc; ../../../../../../../common/drivers/nvm; ../../../../include; ../../../../../avr2025_mac/source/resources/queue/inc; ../../../../../avr2025_mac/include; ../../../../../avr2025_mac/source/resources/buffer/inc; ../../../../../avr2025_mac/source/stb/inc; ../../../../../avr2025_mac/source/sal/inc; ../../../../../../../common/services/ioport; ../../../../../../../common/utils/stdio/stdio_usb; ../../../../../../../xmega/drivers/nvm; ../../../../../../../common/services/sleepmgr; ../../../../../../../common/utils; ../../../../../../../common/services/usb/class/cdc; ../../../../../../../common/services/clock; ../../../../../../../xmega/boards/xmega_a3bu_xplained; ../../../../../../../common/services/usb; ../../../../../../../common/services/delay; ../../../../../../../xmega/boards; ../../../../../../../xmega/drivers/sleep; ../../../../../avr2025_mac/source/tal/inc; ../../../../../avr2025_mac/source/pal; ../../../../../../../common/services/gpio; ../../../../../avr2025_mac/source/pal/common_hw_timer; ../../../zrc/tgt/config; ../..; ../../../../../../../xmega/drivers/usb; ../../../../../../../common/services/spi; ..; ../../../../../../../xmega/drivers/spi; ../../../../../../../xmega/utils/preprocessor; ../../../../../avr2025_mac/source/pal/common_sw_timer; ../../../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; MAC_USER_BUILD_CONFIG; IOPORT_XMEGA_COMPAT; NLDE_HANDLE; SAL_TYPE=ATXMEGA_SAL; DISABLE_TSTAMP_IRQ=1; ZRC_CMD_DISCOVERY; RF4CE_TARGET; TAL_TYPE=AT86RF231; DEBUG=0; VENDOR_DATA; ENABLE_STACK_NVM; ENABLE_TRX_SRAM; TEST_SUITE_DEFINE_ASSERT_MACRO; RF4CE_SECURITY; RSSI_TO_LQI_MAPPING; PBP_REC; PAL_USE_SPI_TRX=1; STB_ON_SAL; REDUCED_PARAM_CHECK; BOARD=XMEGA_A3BU_XPLAINED; ZRC_PROFILE; CHANNEL_AGILITY; PRIVATE_NIB; SIO_HUB; RF4CE_CALLBACK_PARAM; _ASSERT_ENABLE_; HIGHEST_STACK_LAYER=RF4CE; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../avr2025_mac/source/pal/: pal.c pal_ext_trx.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/xmega
    ../../../../../avr2025_mac/source/pal/common_hw_timer/xmega/: hw_timer.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/xmega/lib
    ../../../../../avr2025_mac/source/pal/common_hw_timer/xmega/lib/: xmegaa3_lib_hw_timer.r90
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../avr2025_mac/source/pal/common_sw_timer/: common_sw_timer.c
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../../../avr2025_mac/source/mac/src/: mac_orphan.c mac_process_tal_tx_frame_status.c mac_data_ind.c mac_rx_enable.c mac_data_extract_mhr.c mac_process_beacon_frame.c mac_start.c mac_sync.c mac_associate.c mac.c mac_poll.c mac_mcps_data.c mac_beacon.c mac_dispatcher.c mac_disassociate.c mac_scan.c mac_misc.c mac_tx_coord_realignment_command.c mac_data_req.c mac_security.c mac_pib.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf231/src
    ../../../../../avr2025_mac/source/tal/at86rf231/src/: tal_rx.c tal_pwr_mgmt.c tal_ed.c tal_pib.c tal.c tal_irq_handler.c tal_slotted_csma.c tal_init.c tal_tx.c tal_rx_enable.c
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../avr2025_mac/source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/stb/src
    ../../../../../avr2025_mac/source/stb/src/: stb_armcrypto.c stb_help.c stb.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../avr2025_mac/source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../avr2025_mac/source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/sal/atxmega_sal/src
    ../../../../../avr2025_mac/source/sal/atxmega_sal/src/: sal.c
  group thirdparty/wireless/avr2102_rf4control/lib/zrc/tgt/atxmega256a3bu/iar
    ../../../zrc/tgt/atxmega256a3bu/iar/: librf4ce-zrc-target.r90
  group thirdparty/wireless/avr2102_rf4control/lib/unit_tests
    ../../: unit_tests.c
  group common/services/clock/xmega
    ../../../../../../../common/services/clock/xmega/: sysclk.c
  group common/services/spi/xmega_spi
    ../../../../../../../common/services/spi/xmega_spi/: spi_master.c
  group common/services/sleepmgr/xmega
    ../../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/usb/udc
    ../../../../../../../common/services/usb/udc/: udc.c
  group common/services/usb/class/cdc/device
    ../../../../../../../common/services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c
  group common/services/ioport/xmega
    ../../../../../../../common/services/ioport/xmega/: ioport_compat.c
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_usb
    ../../../../../../../common/utils/stdio/stdio_usb/: stdio_usb.c
  group common/utils/unit_test
    ../../../../../../../common/utils/unit_test/: suite.c
  group common/drivers/nvm/xmega
    ../../../../../../../common/drivers/nvm/xmega/: xmega_nvm.c
  group xmega/drivers/spi
    ../../../../../../../xmega/drivers/spi/: spi.c
  group xmega/drivers/nvm
    ../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/usb
    ../../../../../../../xmega/drivers/usb/: usb_device.c
  group xmega/drivers/tc
    ../../../../../../../xmega/drivers/tc/: tc.c
  group xmega/drivers/cpu
    ../../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../../../xmega/boards/xmega_a3bu_xplained/: init.c
