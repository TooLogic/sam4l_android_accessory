<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\lib_unit_tests.ewp</path>
	</project>
</workspace>
