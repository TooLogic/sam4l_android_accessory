# IAR project serial_bridge_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4LC4C__; ARM_MATH_CM4=true; BOARD=SAM4L_XPLAINED_PRO
  ICCARM.CCIncludePath2: ..; ../../../../../../../common/services/serial/sam_uart; ../../../../../../../common/boards; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../../../../common/services/serial; ../../..; ../../../../../../../common/utils; ../../../../sio2ncp/uart; ../../../../../../../sam/drivers/wdt; ../../../../../../../common/services/clock; ../../../../../../../sam/boards; ../../../../../../../common/utils/stdio/stdio_serial; ../../../../sio2host/uart; ../../../../../../../common/services/delay; ../../../../../../../sam/utils; ../../../../../../../sam/drivers/usart; ../../../../../../../sam/utils/header_files; ../../../../../../../sam/drivers/flashcalw; ../../../../../../../sam/boards/sam4l_xplained_pro; ../../../../../../../common/services/ioport; ../../../../../../../sam/drivers/bpm; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4LC4C__; ARM_MATH_CM4=true; BOARD=SAM4L_XPLAINED_PRO
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: serial_bridge_example_flash.bin
  ILINK.IlinkOutputFile: serial_bridge_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/clock/sam4l
    ../../../../../../../common/services/clock/sam4l/: osc.c sysclk.c pll.c dfll.c
  group common/services/delay/sam
    ../../../../../../../common/services/delay/sam/: cycle_counter.c
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group sam/drivers/bpm
    ../../../../../../../sam/drivers/bpm/: bpm.c
  group sam/drivers/wdt
    ../../../../../../../sam/drivers/wdt/: wdt_sam4l.c
  group sam/drivers/flashcalw
    ../../../../../../../sam/drivers/flashcalw/: flashcalw.c
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c
  group sam/boards/sam4l_xplained_pro
    ../../../../../../../sam/boards/sam4l_xplained_pro/: init.c
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../sam/utils/cmsis/sam4l/source/templates/: exceptions.c system_sam4l.c
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group thirdparty/wireless/addons/sio2ncp/uart
    ../../../../sio2ncp/uart/: sio2ncp.c
  group thirdparty/wireless/addons/serial_bridge
    ../../../: serial_bridge.c
  group thirdparty/wireless/addons/serial_bridge/example
    ../../: main.c
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../sio2host/uart/: sio2host.c
