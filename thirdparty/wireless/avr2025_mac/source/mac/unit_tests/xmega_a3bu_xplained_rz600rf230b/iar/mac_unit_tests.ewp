# IAR project mac_unit_tests.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: FFD; _ASSERT_ENABLE_; DISABLE_TSTAMP_IRQ=1; HIGHEST_STACK_LAYER=MAC; ENABLE_TSTAMP; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT; TAL_TYPE=AT86RF230B; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BEACON_SUPPORT; PAL_USE_SPI_TRX=1
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../pal/common_hw_timer/xmega; ../../../../../../../../common/services/usb/class/cdc/device; ../../../inc; ../../../../../../../../xmega/drivers/pmic; ../../../../../../../../common/services/spi/xmega_spi; ../../../../../../../../xmega/drivers/tc; ../../../../../../../../xmega/utils; ../../../../pal/common_sw_timer; ../../../../resources/queue/inc; ../..; ../../../../tal/at86rf230b/inc; ../../../../../include; ../../../../../../../../xmega/drivers/spi; ../../../../resources/buffer/inc; ../../../../../../../../common/services/ioport; ../../../../../../../../common/utils/stdio/stdio_usb; ../../../../../../../../xmega/drivers/nvm; ../../../../../../../../common/services/sleepmgr; ../../../../../../../../common/utils; ../../../../../../../../common/services/usb/class/cdc; ../../../../../../../../common/services/clock; ../../../../../../../../xmega/boards/xmega_a3bu_xplained; ../../../../../../../../common/services/usb; ../../../../../../../../xmega/boards; ../../../../tal/inc; ../../../../pal; ../../../../../../../../common/services/gpio; ../../../../pal/common_hw_timer; ../../../../../../../../common/services/delay; ../../../../../../../../common/services/usb/udc; ../../../../../../../../xmega/drivers/usb; ../../../../../../../../common/services/spi; ../../../../../../../../common/boards; ..; ../../../../../../../../xmega/utils/preprocessor; ../../../../../../../../xmega/drivers/sleep; ../../../../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; FFD; _ASSERT_ENABLE_; DISABLE_TSTAMP_IRQ=1; HIGHEST_STACK_LAYER=MAC; ENABLE_TSTAMP; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT; TAL_TYPE=AT86RF230B; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BEACON_SUPPORT; PAL_USE_SPI_TRX=1
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../pal/: pal.c pal_ext_trx.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/xmega
    ../../../../pal/common_hw_timer/xmega/: hw_timer.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/xmega/lib
    ../../../../pal/common_hw_timer/xmega/lib/: xmegaa3_lib_hw_timer.r90
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../pal/common_sw_timer/: common_sw_timer.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf230b/src
    ../../../../tal/at86rf230b/src/: tal_pib.c tal_rx_enable.c tal_tx.c tal_pwr_mgmt.c tal_slotted_csma.c tal.c tal_init.c tal_rx.c tal_irq_handler.c tal_ed.c
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../src/: mac_disassociate.c mac_api.c mac_misc.c mac_tx_coord_realignment_command.c mac_associate.c mac_security.c mac_orphan.c mac_rx_enable.c mac_pib.c mac_callback_wrapper.c mac_dispatcher.c mac.c mac_data_ind.c mac_process_tal_tx_frame_status.c mac_start.c mac_sync.c mac_process_beacon_frame.c mac_scan.c mac_data_req.c mac_poll.c mac_mcps_data.c mac_beacon.c mac_data_extract_mhr.c
  group thirdparty/wireless/avr2025_mac/source/mac/unit_tests
    ../../: unit_tests.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../resources/queue/src/: qmm.c
  group common/services/ioport/xmega
    ../../../../../../../../common/services/ioport/xmega/: ioport_compat.c
  group common/services/usb/class/cdc/device
    ../../../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c
  group common/services/usb/udc
    ../../../../../../../../common/services/usb/udc/: udc.c
  group common/services/clock/xmega
    ../../../../../../../../common/services/clock/xmega/: sysclk.c
  group common/services/sleepmgr/xmega
    ../../../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/spi/xmega_spi
    ../../../../../../../../common/services/spi/xmega_spi/: spi_master.c
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_usb
    ../../../../../../../../common/utils/stdio/stdio_usb/: stdio_usb.c
  group common/utils/unit_test
    ../../../../../../../../common/utils/unit_test/: suite.c
  group xmega/drivers/usb
    ../../../../../../../../xmega/drivers/usb/: usb_device.c
  group xmega/drivers/spi
    ../../../../../../../../xmega/drivers/spi/: spi.c
  group xmega/drivers/tc
    ../../../../../../../../xmega/drivers/tc/: tc.c
  group xmega/drivers/nvm
    ../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/cpu
    ../../../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../../../../xmega/boards/xmega_a3bu_xplained/: init.c
