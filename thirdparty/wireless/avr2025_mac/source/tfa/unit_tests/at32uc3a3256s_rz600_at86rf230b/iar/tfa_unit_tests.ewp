# IAR project tfa_unit_tests.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: FFD; ENABLE_TFA; _ASSERT_ENABLE_; HIGHEST_STACK_LAYER=TAL; UDD_ENABLE; TEST_SUITE_DEFINE_ASSERT_MACRO; TAL_TYPE=AT86RF230B; BOARD=RZ600; DISABLE_TSTAMP_IRQ=1; PAL_USE_SPI_TRX=1
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../../common/services/usb/class/cdc; ../../../../../../../../common/services/usb/class/cdc/device; ../../../../mac/inc; ../../../../../../../../avr32/boards; ../../../../../../../../common/services/spi/uc3_spi; ../../../../pal/common_sw_timer; ../../../../../../../../avr32/drivers/usbb; ../../../../../../../../avr32/drivers/pm; ../../../../resources/queue/inc; ../../../../tal/at86rf230b/inc; ../../../../../include; ../../../../pal/common_hw_timer/uc3; ../../../../../../../../avr32/drivers/tc; ../../../../../../../../common/utils/stdio/stdio_usb; ../../../inc; ../../../../../../../../avr32/utils; ../../../../../../../../avr32/drivers/gpio; ../../../../resources/buffer/inc; ../../../../../../../../common/utils; ../../../../../../../../avr32/boards/rz600; ../../../../../../../../avr32/drivers/spi; ..; ../../../../../../../../common/services/sleepmgr; ../../../../../../../../common/services/clock; ../..; ../../../../../../../../common/services/usb; ../../../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../tal/inc; ../../../../pal; ../../../../pal/common_hw_timer; ../../../../../../../../common/services/delay; ../../../../../../../../common/services/usb/udc; ../../../../../../../../common/services/spi; ../../../../../../../../common/boards; ../../../../../../../../avr32/drivers/flashc; ../../../../../../../../common/services/ioport; ../../../../../../../../avr32/utils/preprocessor; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../avr32/utils/linker_scripts/at32uc3a3/256s/iar/lnkuc3a3256s.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../pal/: pal_ext_trx.c pal.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/uc3
    ../../../../pal/common_hw_timer/uc3/: hw_timer.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/uc3/lib
    ../../../../pal/common_hw_timer/uc3/lib/: uc3_lib_hw_timer.r82
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../pal/common_sw_timer/: common_sw_timer.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf230b/src
    ../../../../tal/at86rf230b/src/: tal_pib.c tal_slotted_csma.c tal_rx_enable.c tal_tx.c tal_pwr_mgmt.c tal.c tal_init.c tal_rx.c tal_irq_handler.c tal_ed.c
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tfa/unit_tests
    ../../: unit_tests.c
  group thirdparty/wireless/avr2025_mac/source/tfa/at86rf230b/src
    ../../../at86rf230b/src/: tfa.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../resources/queue/src/: qmm.c
  group avr32/drivers/pm
    ../../../../../../../../avr32/drivers/pm/: pm_conf_clocks.c pm.c power_clocks_lib.c
  group avr32/drivers/usbb
    ../../../../../../../../avr32/drivers/usbb/: usbb_device.c
  group avr32/drivers/flashc
    ../../../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/gpio
    ../../../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/tc
    ../../../../../../../../avr32/drivers/tc/: tc.c
  group avr32/drivers/spi
    ../../../../../../../../avr32/drivers/spi/: spi.c
  group avr32/boards/rz600
    ../../../../../../../../avr32/boards/rz600/: led.c init.c
  group avr32/utils/startup
    ../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82
  group common/utils/unit_test
    ../../../../../../../../common/utils/unit_test/: suite.c
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_usb
    ../../../../../../../../common/utils/stdio/stdio_usb/: stdio_usb.c
  group common/services/usb/udc
    ../../../../../../../../common/services/usb/udc/: udc.c
  group common/services/usb/class/cdc/device
    ../../../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c
  group common/services/clock/uc3a3_a4
    ../../../../../../../../common/services/clock/uc3a3_a4/: sysclk.c
  group common/services/sleepmgr/uc3
    ../../../../../../../../common/services/sleepmgr/uc3/: sleepmgr.c
  group common/services/spi/uc3_spi
    ../../../../../../../../common/services/spi/uc3_spi/: spi_master.c
