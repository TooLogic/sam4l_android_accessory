# IAR project tfa_unit_tests.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: FFD; ENABLE_TFA; _ASSERT_ENABLE_; HIGHEST_STACK_LAYER=TAL; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT; TAL_TYPE=AT86RF230B; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; DISABLE_TSTAMP_IRQ=1; PAL_USE_SPI_TRX=1
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../pal/common_hw_timer/xmega; ../../../../../../../../common/services/usb/class/cdc/device; ../../../../mac/inc; ../../../../../../../../xmega/drivers/pmic; ../../../../../../../../common/services/spi/xmega_spi; ..; ../../../../../../../../xmega/utils; ../../../../../../../../common/services/usb/udc; ../../../../pal/common_sw_timer; ../../../../resources/queue/inc; ../../../../tal/at86rf230b/inc; ../../../../../include; ../../../../resources/buffer/inc; ../../../../../../../../common/services/ioport; ../../../inc; ../../../../../../../../xmega/drivers/nvm; ../../../../../../../../common/services/sleepmgr; ../../../../../../../../common/utils; ../../../../../../../../common/services/usb/class/cdc; ../../../../../../../../common/services/clock; ../../../../../../../../common/utils/stdio/stdio_usb; ../../../../../../../../xmega/boards/xmega_a3bu_xplained; ../../../../../../../../common/services/usb; ../../../../../../../../xmega/drivers/tc; ../../../../../../../../xmega/boards; ../../../../tal/inc; ../../../../pal; ../../../../../../../../common/services/gpio; ../../../../pal/common_hw_timer; ../../../../../../../../common/services/delay; ../..; ../../../../../../../../xmega/drivers/usb; ../../../../../../../../common/services/spi; ../../../../../../../../common/boards; ../../../../../../../../xmega/drivers/spi; ../../../../../../../../xmega/utils/preprocessor; ../../../../../../../../xmega/drivers/sleep; ../../../../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; FFD; ENABLE_TFA; _ASSERT_ENABLE_; HIGHEST_STACK_LAYER=TAL; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT; TAL_TYPE=AT86RF230B; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; DISABLE_TSTAMP_IRQ=1; PAL_USE_SPI_TRX=1
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../pal/: pal_ext_trx.c pal.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/xmega
    ../../../../pal/common_hw_timer/xmega/: hw_timer.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/xmega/lib
    ../../../../pal/common_hw_timer/xmega/lib/: xmegaa3_lib_hw_timer.r90
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../pal/common_sw_timer/: common_sw_timer.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf230b/src
    ../../../../tal/at86rf230b/src/: tal_pib.c tal_rx_enable.c tal_tx.c tal_pwr_mgmt.c tal_slotted_csma.c tal.c tal_init.c tal_rx.c tal_irq_handler.c tal_ed.c
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/tfa/at86rf230b/src
    ../../../at86rf230b/src/: tfa.c
  group thirdparty/wireless/avr2025_mac/source/tfa/unit_tests
    ../../: unit_tests.c
  group common/services/ioport/xmega
    ../../../../../../../../common/services/ioport/xmega/: ioport_compat.c
  group common/services/usb/class/cdc/device
    ../../../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c
  group common/services/usb/udc
    ../../../../../../../../common/services/usb/udc/: udc.c
  group common/services/clock/xmega
    ../../../../../../../../common/services/clock/xmega/: sysclk.c
  group common/services/sleepmgr/xmega
    ../../../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/spi/xmega_spi
    ../../../../../../../../common/services/spi/xmega_spi/: spi_master.c
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_usb
    ../../../../../../../../common/utils/stdio/stdio_usb/: stdio_usb.c
  group common/utils/unit_test
    ../../../../../../../../common/utils/unit_test/: suite.c
  group xmega/drivers/usb
    ../../../../../../../../xmega/drivers/usb/: usb_device.c
  group xmega/drivers/spi
    ../../../../../../../../xmega/drivers/spi/: spi.c
  group xmega/drivers/tc
    ../../../../../../../../xmega/drivers/tc/: tc.c
  group xmega/drivers/nvm
    ../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/cpu
    ../../../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../../../../xmega/boards/xmega_a3bu_xplained/: init.c
