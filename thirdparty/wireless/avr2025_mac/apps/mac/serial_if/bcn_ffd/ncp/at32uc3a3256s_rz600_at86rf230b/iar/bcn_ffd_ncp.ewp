# IAR project bcn_ffd_ncp.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: FFD; TEST_HARNESS; UDD_ENABLE; HIGHEST_STACK_LAYER=MAC; ENABLE_TSTAMP; TEST_HARNESS_BIG_ENDIAN; TAL_TYPE=AT86RF230B; BEACON_SUPPORT; BOARD=RZ600; DISABLE_TSTAMP_IRQ=1; PAL_USE_SPI_TRX=1
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../../../../common/services/usb/class/cdc/device; ../../../../../../../source/mac/inc; ..; ../../../../../../../../../../avr32/boards; ../../../../../../../../../../common/services/spi/uc3_spi; ../../../../../../../source/pal/common_sw_timer; ../../../../../../../../../../avr32/drivers/usbb; ../../../../../../../../../../avr32/drivers/pm; ../../../../../../../source/resources/queue/inc; ../../../../../../../source/tal/at86rf230b/inc; ../../../../../../../include; ../..; ../../../../../../../source/pal/common_hw_timer/uc3; ../../../../../../../../../../avr32/drivers/tc; ../../../../../../../../addons/sio2host/usb; ../../../../../../../../../../common/utils/stdio/stdio_usb; ../../../../../../../../../../avr32/utils; ../../../../../../../../../../avr32/drivers/gpio; ../../../../../../../../../../common/services/sleepmgr; ../../../../../../../../../../common/utils; ../../../../../../../../../../avr32/boards/rz600; ../../../../../../../../../../avr32/drivers/spi; ../../../../../../../../../../common/services/usb/class/cdc; ../../../../../../../addons/serial_if/inc; ../../../../../../../../../../common/services/clock; ../../../../../../../source/resources/buffer/inc; ../../../../../../../../../../common/services/usb; ../../../../../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../../source/tal/inc; ../../../../../../../source/pal; ../../../../../../../source/pal/common_hw_timer; ../../../../../../../../../../common/services/delay; ../../../../../../../../../../common/services/usb/udc; ../../../../../../../../../../common/services/spi; ../../../../../../../../../../common/boards; ../../../../../../../../../../avr32/drivers/flashc; ../../../../../../../../../../common/services/ioport; ../../../../../../../../../../avr32/utils/preprocessor; ../../../..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../../avr32/utils/linker_scripts/at32uc3a3/256s/iar/lnkuc3a3256s.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../../../source/pal/: pal.c pal_ext_trx.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/uc3
    ../../../../../../../source/pal/common_hw_timer/uc3/: hw_timer.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/uc3/lib
    ../../../../../../../source/pal/common_hw_timer/uc3/lib/: uc3_lib_hw_timer.r82
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../../../source/pal/common_sw_timer/: common_sw_timer.c
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../../../../../source/mac/src/: mac_beacon.c mac_start.c mac_security.c mac_associate.c mac_scan.c mac_pib.c mac_process_tal_tx_frame_status.c mac_data_ind.c mac_orphan.c mac.c mac_poll.c mac_callback_wrapper.c mac_sync.c mac_misc.c mac_dispatcher.c mac_rx_enable.c mac_tx_coord_realignment_command.c mac_data_extract_mhr.c mac_disassociate.c mac_data_req.c mac_api.c mac_process_beacon_frame.c mac_mcps_data.c
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../../../source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf230b/src
    ../../../../../../../source/tal/at86rf230b/src/: tal_rx_enable.c tal_init.c tal_ed.c tal.c tal_rx.c tal_pwr_mgmt.c tal_pib.c tal_tx.c tal_slotted_csma.c tal_irq_handler.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../../../source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../../../source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/addons/serial_if/src
    ../../../../../../../addons/serial_if/src/: serial_interface.c
  group thirdparty/wireless/avr2025_mac/apps/mac/serial_if
    ../../../../: main.c
  group thirdparty/wireless/addons/sio2host/usb
    ../../../../../../../../addons/sio2host/usb/: sio2host.c
  group avr32/drivers/usbb
    ../../../../../../../../../../avr32/drivers/usbb/: usbb_device.c
  group avr32/drivers/flashc
    ../../../../../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/spi
    ../../../../../../../../../../avr32/drivers/spi/: spi.c
  group avr32/drivers/pm
    ../../../../../../../../../../avr32/drivers/pm/: pm_conf_clocks.c power_clocks_lib.c pm.c
  group avr32/drivers/tc
    ../../../../../../../../../../avr32/drivers/tc/: tc.c
  group avr32/drivers/gpio
    ../../../../../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/boards/rz600
    ../../../../../../../../../../avr32/boards/rz600/: led.c init.c
  group avr32/utils/startup
    ../../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82
  group common/services/sleepmgr/uc3
    ../../../../../../../../../../common/services/sleepmgr/uc3/: sleepmgr.c
  group common/services/usb/class/cdc/device
    ../../../../../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c
  group common/services/usb/udc
    ../../../../../../../../../../common/services/usb/udc/: udc.c
  group common/services/spi/uc3_spi
    ../../../../../../../../../../common/services/spi/uc3_spi/: spi_master.c
  group common/services/clock/uc3a3_a4
    ../../../../../../../../../../common/services/clock/uc3a3_a4/: sysclk.c
  group common/utils/stdio
    ../../../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_usb
    ../../../../../../../../../../common/utils/stdio/stdio_usb/: stdio_usb.c
