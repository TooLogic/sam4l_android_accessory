# IAR project bcn_ffd_ncp.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x200
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m256rfr2 ATmega256RFR2
  ICCAVR.CCDefines: FFD; TEST_HARNESS; HIGHEST_STACK_LAYER=MAC; ENABLE_TSTAMP; BOARD=ATMEGA256RFR2_XPLAINED_PRO; BEACON_SUPPORT; TAL_TYPE=ATMEGARFR2
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../source/mac/inc; ../../../../../../../../../../mega/utils; ..; ../../../../../../../source/pal/common_sw_timer; ../../../../../../../source/resources/queue/inc; ../../../../../../../../../../mega/drivers/usart; ../../../../../../../include; ../../../../../../../../addons/sio2host/uart; ../..; ../../../../../../../../../../common/services/serial; ../../../../../../../../../../common/services/clock; ../../../../../../../source/resources/buffer/inc; ../../../../../../../../../../common/utils; ../../../../../../../source/tal/atmegarfr2/inc; ../../../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../../../../mega/drivers/cpu; ../../../../../../../addons/serial_if/inc; ../../../../../../../source/pal/mega/drivers/tc; ../../../../../../../../../../mega/boards; ../../../../../../../source/pal/common_hw_timer/mega; ../../../../../../../../../../common/services/serial/megarf_usart; ../../../../../../../source/tal/inc; ../../../../../../../source/pal; ../../../../../../../../../../common/services/gpio; ../../../../../../../source/pal/common_hw_timer; ../../../../../../../../../../common/services/delay; ../../../../../../../../../../common/boards; ../../../../../../../../../../common/services/ioport; ../../../../../../../../../../mega/boards/atmega256rfr2_xplained_pro; ../../../..; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; FFD; TEST_HARNESS; HIGHEST_STACK_LAYER=MAC; ENABLE_TSTAMP; BOARD=ATMEGA256RFR2_XPLAINED_PRO; BEACON_SUPPORT; TAL_TYPE=ATMEGARFR2
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../../../source/pal/: pal.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/mega
    ../../../../../../../source/pal/common_hw_timer/mega/: hw_timer.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/mega/lib
    ../../../../../../../source/pal/common_hw_timer/mega/lib/: mega_lib_hw_timer.r90
  group thirdparty/wireless/avr2025_mac/source/pal/mega/drivers/tc
    ../../../../../../../source/pal/mega/drivers/tc/: tc_megarf.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../../../source/pal/common_sw_timer/: common_sw_timer.c
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../../../../../source/mac/src/: mac_beacon.c mac_security.c mac_associate.c mac_pib.c mac_orphan.c mac.c mac_start.c mac_poll.c mac_scan.c mac_sync.c mac_rx_enable.c mac_dispatcher.c mac_callback_wrapper.c mac_data_ind.c mac_data_extract_mhr.c mac_disassociate.c mac_misc.c mac_data_req.c mac_process_tal_tx_frame_status.c mac_tx_coord_realignment_command.c mac_api.c mac_process_beacon_frame.c mac_mcps_data.c
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../../../source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/atmegarfr2/src
    ../../../../../../../source/tal/atmegarfr2/src/: tal_slotted_csma.c tal_ed.c tal_init.c tal_rx.c tal_rx_enable.c tal_pwr_mgmt.c tal_pib.c tal_tx.c tal.c tal_irq_handler.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../../../source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../../../source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/addons/serial_if/src
    ../../../../../../../addons/serial_if/src/: serial_interface.c
  group thirdparty/wireless/avr2025_mac/apps/mac/serial_if
    ../../../../: main.c
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../../../../addons/sio2host/uart/: sio2host.c
  group common/services/clock/mega
    ../../../../../../../../../../common/services/clock/mega/: sysclk.c
  group common/services/serial
    ../../../../../../../../../../common/services/serial/: usart_serial.c
  group common/utils/stdio
    ../../../../../../../../../../common/utils/stdio/: read.c write.c
  group mega/boards/atmega256rfr2_xplained_pro
    ../../../../../../../../../../mega/boards/atmega256rfr2_xplained_pro/: init.c
  group mega/drivers/usart
    ../../../../../../../../../../mega/drivers/usart/: usart_megarf.c
