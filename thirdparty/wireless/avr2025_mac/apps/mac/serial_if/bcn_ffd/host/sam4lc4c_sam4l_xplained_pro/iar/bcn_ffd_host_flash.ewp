# IAR project bcn_ffd_host_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: FFD; TEST_HARNESS; BOARD=SAM4L_XPLAINED_PRO; HIGHEST_STACK_LAYER=MAC; ENABLE_TSTAMP; BEACON_SUPPORT; __SAM4LC4C__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam/utils/header_files; ../../../../../../../source/mac/inc; ../../../../../../../addons/api_parser/inc; ../../../../../../../../../../common/boards; ../../../../../../../../../../sam/utils/preprocessor; ../../../../../../../source/pal/common_sw_timer; ..; ../../../../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../../include; ../../../../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../..; ../../../../../../../../../../common/services/serial; ../../../../../../../../../../common/utils; ../../../../../../../../addons/sio2ncp/uart; ../../../../../../../../../../sam/drivers/wdt; ../../../../../../../addons/serial_if/inc; ../../../../../../../../../../common/services/clock; ../../../../../../../../../../sam/boards; ../../../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../../addons/sio2host/uart; ../../../../../../../source/pal/common_hw_timer; ../../../../../../../../../../common/services/delay; ../../../../../../../../../../sam/utils; ../../../../../../../../../../sam/drivers/tc; ../../../../../../../../../../sam/drivers/usart; ../../../../../../../../../../common/services/serial/sam_uart; ../../../../../../../../../../sam/drivers/flashcalw; ../../../../../../../../../../sam/boards/sam4l_xplained_pro; ../../../../../../../../../../common/services/ioport; ../../../../../../../../../../sam/drivers/bpm; ../../../..; ../../../../../../../source/pal/common_hw_timer/sam; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: bcn_ffd_host_flash.bin
  ILINK.IlinkOutputFile: bcn_ffd_host_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/sam
    ../../../../../../../source/pal/common_hw_timer/sam/: hw_timer.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/sam/lib
    ../../../../../../../source/pal/common_hw_timer/sam/lib/: sam4l_lib_hw_timer.a
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../../../source/pal/common_sw_timer/: common_sw_timer.c
  group thirdparty/wireless/avr2025_mac/apps/mac/serial_if
    ../../../../: main.c
  group thirdparty/wireless/avr2025_mac/addons/serial_if/src
    ../../../../../../../addons/serial_if/src/: serial_interface.c
  group thirdparty/wireless/avr2025_mac/addons/api_parser/src
    ../../../../../../../addons/api_parser/src/: api_decoder.c api_encoder.c
  group thirdparty/wireless/addons/sio2ncp/uart
    ../../../../../../../../addons/sio2ncp/uart/: sio2ncp.c
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../../../../addons/sio2host/uart/: sio2host.c
  group common/utils/interrupt
    ../../../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../../../../../../common/utils/stdio/: write.c read.c
  group common/services/clock/sam4l
    ../../../../../../../../../../common/services/clock/sam4l/: sysclk.c dfll.c pll.c osc.c
  group common/services/delay/sam
    ../../../../../../../../../../common/services/delay/sam/: cycle_counter.c
  group common/services/serial
    ../../../../../../../../../../common/services/serial/: usart_serial.c
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/: exceptions.c system_sam4l.c
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/drivers/tc
    ../../../../../../../../../../sam/drivers/tc/: tc.c
  group sam/drivers/flashcalw
    ../../../../../../../../../../sam/drivers/flashcalw/: flashcalw.c
  group sam/drivers/usart
    ../../../../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/wdt
    ../../../../../../../../../../sam/drivers/wdt/: wdt_sam4l.c
  group sam/drivers/bpm
    ../../../../../../../../../../sam/drivers/bpm/: bpm.c
  group sam/boards/sam4l_xplained_pro
    ../../../../../../../../../../sam/boards/sam4l_xplained_pro/: init.c
