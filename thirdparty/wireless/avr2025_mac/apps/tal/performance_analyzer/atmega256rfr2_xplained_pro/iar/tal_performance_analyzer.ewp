# IAR project tal_performance_analyzer.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m256rfr2 ATmega256RFR2
  ICCAVR.CCDefines: FFD; ANTENNA_DIVERSITY=1; ENABLE_TFA; TRX_REG_RAW_VALUE; HIGHEST_STACK_LAYER=TAL; HIGH_DATA_RATE_SUPPORT; BOARD=ATMEGA256RFR2_XPLAINED_PRO; TAL_TYPE=ATMEGARFR2
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../source/mac/inc; ../../../../../../../../mega/utils; ..; ../../../../../source/pal/common_sw_timer; ../../../../../source/resources/queue/inc; ../../../../../../../../mega/drivers/usart; ../../../../../include; ../../../../../../addons/sio2host/uart; ../..; ../../../../../../../../common/services/serial; ../../../../../../../../common/services/ioport; ../../../../../../../../common/services/clock; ../../../../../source/tfa/inc; ../../../../../source/resources/buffer/inc; ../../../../../../../../common/utils; ../../../../../source/tal/atmegarfr2/inc; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../../mega/drivers/cpu; ../../../../../source/pal/mega/drivers/tc; ../../../../../../../../mega/boards; ../../../../../source/pal/common_hw_timer/mega; ../../../../../../../../common/services/serial/megarf_usart; ../../../../../source/tal/inc; ../../../../../source/pal; ../../../../../../../../common/services/gpio; ../../../../../source/pal/common_hw_timer; ../../../../../../../../common/services/delay; ../../../../../../../../common/boards; ../../inc; ../../../../../../../../mega/boards/atmega256rfr2_xplained_pro; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; FFD; ANTENNA_DIVERSITY=1; ENABLE_TFA; TRX_REG_RAW_VALUE; HIGHEST_STACK_LAYER=TAL; HIGH_DATA_RATE_SUPPORT; BOARD=ATMEGA256RFR2_XPLAINED_PRO; TAL_TYPE=ATMEGARFR2
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../source/pal/: pal.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/mega
    ../../../../../source/pal/common_hw_timer/mega/: hw_timer.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/mega/lib
    ../../../../../source/pal/common_hw_timer/mega/lib/: mega_lib_hw_timer.r90
  group thirdparty/wireless/avr2025_mac/source/pal/mega/drivers/tc
    ../../../../../source/pal/mega/drivers/tc/: tc_megarf.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../source/pal/common_sw_timer/: common_sw_timer.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/tal/atmegarfr2/src
    ../../../../../source/tal/atmegarfr2/src/: tal_pib.c tal_irq_handler.c tal.c tal_tx.c tal_pwr_mgmt.c tal_ed.c tal_init.c tal_rx_enable.c tal_rx.c tal_slotted_csma.c
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tfa/atmegarfr2/src
    ../../../../../source/tfa/atmegarfr2/src/: tfa.c
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer/src
    ../../src/: perf_api_serial_handler.c user_interface.c wait_for_event.c per_mode_receptor.c range_measure.c per_mode_common_utils.c peer_search_receptor.c per_mode_initiator.c init_state.c peer_search_initiator.c main.c
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../../addons/sio2host/uart/: sio2host.c
  group mega/boards/atmega256rfr2_xplained_pro
    ../../../../../../../../mega/boards/atmega256rfr2_xplained_pro/: init.c
  group mega/drivers/usart
    ../../../../../../../../mega/drivers/usart/: usart_megarf.c
  group common/services/clock/mega
    ../../../../../../../../common/services/clock/mega/: sysclk.c
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: read.c write.c
