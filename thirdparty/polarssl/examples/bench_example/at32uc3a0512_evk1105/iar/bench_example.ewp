# IAR project bench_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1105
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../..; ../../../../../../common/services/serial; ../../../../../../avr32/drivers/gpio; ../../../../../../common/services/clock; ../../../../../../common/services/serial/uc3_usart; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/boards; ../../../../../../avr32/drivers/usart; ../../../../../../avr32/drivers/flashc; ../../../../../../avr32/boards; ../../../../../../avr32/utils; ../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../avr32/utils/preprocessor; ../../../../../../common/utils; ../../../../include; ../../../../../../avr32/drivers/intc; ..; ../../../../../../avr32/boards/evk1105; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1105
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/polarssl
    ../../../../: x509parse.c base64.c timing.c xtea.c md2.c arc4.c ssl_cli.c sha1.c certs.c ssl_srv.c padlock.c camellia.c bignum.c sha2.c havege.c dhm.c debug.c rsa.c des.c aes.c sha4.c md5.c md4.c
  group thirdparty/polarssl/examples/bench_example
    ../../: benchmark.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/uc3a0_a1
    ../../../../../../common/services/clock/uc3a0_a1/: sysclk.c
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/intc
    ../../../../../../avr32/drivers/intc/: intc.c exception.s82
  group avr32/drivers/flashc
    ../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/usart
    ../../../../../../avr32/drivers/usart/: usart.c
  group avr32/boards/evk1105
    ../../../../../../avr32/boards/evk1105/: led.c init.c
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82
