# IAR project png_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1FFFFFF
  ICCAVR32.CCDefines: BOARD=EVK1104
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../avr32/components/display/et024006dhu; ../../../../../avr32/utils/preprocessor; ../../../../../common/services/clock; ../../../../../avr32/utils/debug; ../../../../../avr32/drivers/ebi/smc; ../../../../../common/boards; ../../../../../avr32/drivers/ebi/sdramc; ../../../../../avr32/drivers/usart; ../../../../../avr32/drivers/flashc; ../../../../../avr32/boards/evk1104; ../../../../../avr32/boards; ../../../../../avr32/utils; ../../../../../avr32/drivers/cpu/cycle_counter; ../../..; ../../../../../avr32/drivers/gpio; ../../../../../common/utils; ../../../../../avr32/drivers/pm; ../../../../../avr32/drivers/intc; ../..; ../../../../../avr32/components/memory/sdram; ../../../../../common/services/delay; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1104
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../lnkuc3a3256_extsdram.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/lodepng
    ../../../: lodepng.c
  group thirdparty/lodepng/example
    ../../: lodepng_example.c
  group avr32/drivers/pm
    ../../../../../avr32/drivers/pm/: pm.c power_clocks_lib.c pm_conf_clocks.c
  group avr32/drivers/ebi/sdramc
    ../../../../../avr32/drivers/ebi/sdramc/: sdramc.c
  group avr32/drivers/ebi/smc
    ../../../../../avr32/drivers/ebi/smc/: smc.c
  group avr32/drivers/intc
    ../../../../../avr32/drivers/intc/: intc.c exception.s82
  group avr32/drivers/flashc
    ../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/usart
    ../../../../../avr32/drivers/usart/: usart.c
  group avr32/drivers/gpio
    ../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/utils/debug
    ../../../../../avr32/utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../../avr32/utils/startup/: trampoline_uc3.s82
  group avr32/components/display/et024006dhu
    ../../../../../avr32/components/display/et024006dhu/: et024006dhu.c
  group avr32/boards/evk1104
    ../../../../../avr32/boards/evk1104/: led.c
  group common/services/clock/uc3a3_a4
    ../../../../../common/services/clock/uc3a3_a4/: sysclk.c
