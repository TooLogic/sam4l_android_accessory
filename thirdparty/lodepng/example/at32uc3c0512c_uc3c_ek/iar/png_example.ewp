# IAR project png_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1FFFFFF
  ICCAVR32.CCDefines: BOARD=UC3C_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../avr32/drivers/scif; ../../../../../avr32/drivers/ebi/sdramc; ../../../../../avr32/boards; ../../../../../avr32/drivers/pm; ../../../../../avr32/components/display/et024006dhu; ../../../../../avr32/boards/uc3c_ek; ../../../../../avr32/utils/debug; ../../../../../avr32/utils; ../../..; ../../../../../avr32/drivers/gpio; ../../../../../common/utils; ../../../../../avr32/components/memory/sdram; ../../../../../common/services/clock; ../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../common/services/delay; ../../../../../avr32/drivers/ebi/smc; ../../../../../common/boards; ../../../../../avr32/drivers/usart; ../../../../../avr32/drivers/flashc; ../../../../../avr32/utils/preprocessor; ../../../../../avr32/drivers/intc; ../..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3C_EK
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../lnkuc3c0512c_extsdram.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/clock/uc3c
    ../../../../../common/services/clock/uc3c/: osc.c pll.c sysclk.c
  group thirdparty/lodepng
    ../../../: lodepng.c
  group thirdparty/lodepng/example
    ../../: lodepng_example.c
  group avr32/drivers/ebi/sdramc
    ../../../../../avr32/drivers/ebi/sdramc/: sdramc.c
  group avr32/drivers/ebi/smc
    ../../../../../avr32/drivers/ebi/smc/: smc.c
  group avr32/drivers/intc
    ../../../../../avr32/drivers/intc/: intc.c exception.s82
  group avr32/drivers/gpio
    ../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/pm
    ../../../../../avr32/drivers/pm/: power_clocks_lib.c pm_uc3c.c
  group avr32/drivers/usart
    ../../../../../avr32/drivers/usart/: usart.c
  group avr32/drivers/flashc
    ../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/scif
    ../../../../../avr32/drivers/scif/: scif_uc3c.c
  group avr32/utils/debug
    ../../../../../avr32/utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../../avr32/utils/startup/: trampoline_uc3.s82
  group avr32/boards/uc3c_ek
    ../../../../../avr32/boards/uc3c_ek/: led.c
  group avr32/components/display/et024006dhu
    ../../../../../avr32/components/display/et024006dhu/: et024006dhu.c
