# IAR project ijg_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1FFFFFF
  ICCAVR32.CCDefines: BOARD=EVK1105
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../..; ../../../../../avr32/drivers/ebi/sdramc; ../../../../../avr32/boards; ../../../../../avr32/drivers/pm; ../../../../../avr32/components/display/et024006dhu; ../../../../../avr32/utils/debug; ../../../../../avr32/boards/evk1105; ../../../../../avr32/utils; ../../../../../avr32/drivers/gpio; ../../../../../common/utils; ../../../../../avr32/components/memory/sdram; ../../..; ../../../../../common/services/clock; ../../../../../avr32/drivers/pwm; ../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../common/services/delay; ../../../../../avr32/drivers/ebi/smc; ../../../../../common/boards; ../../../../../avr32/drivers/usart; ../../../../../avr32/drivers/flashc; ../../../../../avr32/utils/preprocessor; ../../../../../avr32/drivers/intc; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1105
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../lnkuc3a0512_extsdram.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/ijg
    ../../../: jdmarker.c jquant2.c jccoefct.c jdpostct.c jdphuff.c jerror.c jddctmgr.c jfdctfst.c jcparam.c jcphuff.c jcmainct.c jcsample.c jdsample.c jcomapi.c jdmainct.c jcinit.c jidctint.c jfdctint.c jidctflt.c jdapimin.c jdapistd.c jchuff.c jidctfst.c jdtrans.c jquant1.c jdmerge.c jcdctmgr.c jidctred.c jdhuff.c jdmaster.c jmemnobs.c jcprepct.c jctrans.c jfdctflt.c jmemmgr.c jccolor.c jcmaster.c jdcolor.c jutils.c jdcoefct.c jcapistd.c jdinput.c jcmarker.c
  group thirdparty/ijg/example
    ../../: jdatasrc.c ijg_example.c
  group avr32/drivers/pm
    ../../../../../avr32/drivers/pm/: pm.c pm_conf_clocks.c power_clocks_lib.c
  group avr32/drivers/ebi/sdramc
    ../../../../../avr32/drivers/ebi/sdramc/: sdramc.c
  group avr32/drivers/ebi/smc
    ../../../../../avr32/drivers/ebi/smc/: smc.c
  group avr32/drivers/intc
    ../../../../../avr32/drivers/intc/: intc.c exception.s82
  group avr32/drivers/usart
    ../../../../../avr32/drivers/usart/: usart.c
  group avr32/drivers/flashc
    ../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/gpio
    ../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/pwm
    ../../../../../avr32/drivers/pwm/: pwm.c
  group avr32/boards/evk1105
    ../../../../../avr32/boards/evk1105/: led.c
  group avr32/utils/debug
    ../../../../../avr32/utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../../avr32/utils/startup/: trampoline_uc3.s82
  group avr32/components/display/et024006dhu
    ../../../../../avr32/components/display/et024006dhu/: et024006dhu.c
  group common/services/clock/uc3a0_a1
    ../../../../../common/services/clock/uc3a0_a1/: sysclk.c
