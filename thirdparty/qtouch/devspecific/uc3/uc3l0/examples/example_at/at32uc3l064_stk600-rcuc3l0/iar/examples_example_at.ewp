# IAR project examples_example_at.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=STK600_RCUC3L0
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../common; ../../../../../../../../../avr32/utils; ../../../../../../../../../avr32/drivers/ast; ../../../../../../../../../avr32/utils/preprocessor; ../..; ../../../../../../../../../common/services/clock; ../../../../../../../../../common/boards; ../../../../../../../../../avr32/boards; ../../../../../../../../../avr32/drivers/usart; ../../../../../../../../../avr32/drivers/scif; ../../../../../../../../../avr32/drivers/pm; ..; ../../../../include; ../../../../../../../../../avr32/drivers/gpio; ../../../../../../../../../avr32/drivers/flashcdw; ../../../../../../../../../common/services/sleepmgr; ../../../../../../../../../common/utils; ../../../../../../../qdebug; ../../../../../../../../../avr32/boards/stk600/rcuc3l0; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=STK600_RCUC3L0
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../avr32/utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/qtouch/devspecific/uc3/uc3l0/lib/iar
    ../../../../lib/iar/: libuc3l-qtouch-iar.r82
  group thirdparty/qtouch/devspecific/uc3/uc3l0/common
    ../../../../common/: SPI_Master.c
  group thirdparty/qtouch/devspecific/uc3/uc3l0/examples/example_at
    ../../: main.c
  group thirdparty/qtouch/qdebug
    ../../../../../../../qdebug/: QDebugTransport.c QDebug_at32uc3l.c
  group avr32/drivers/usart
    ../../../../../../../../../avr32/drivers/usart/: usart.c
  group avr32/drivers/pm
    ../../../../../../../../../avr32/drivers/pm/: power_clocks_lib.c pm_uc3l.c
  group avr32/drivers/scif
    ../../../../../../../../../avr32/drivers/scif/: scif_uc3l.c
  group avr32/drivers/flashcdw
    ../../../../../../../../../avr32/drivers/flashcdw/: flashcdw.c
  group avr32/drivers/ast
    ../../../../../../../../../avr32/drivers/ast/: ast.c
  group avr32/drivers/gpio
    ../../../../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/boards/stk600/rcuc3l0
    ../../../../../../../../../avr32/boards/stk600/rcuc3l0/: led.c
  group avr32/utils/startup
    ../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82
  group common/services/sleepmgr/uc3
    ../../../../../../../../../common/services/sleepmgr/uc3/: sleepmgr.c
  group common/services/clock/uc3l
    ../../../../../../../../../common/services/clock/uc3l/: osc.c dfll.c sysclk.c
