# IAR project lwip_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4E16E Atmel SAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  ICCARM.CCIncludePath2: ../../network; ../../../../../sam/utils/preprocessor; ../../../../../sam/components/ethernet_phy/ksz8051mnl; ../../../../../sam/drivers/pmc; ../../network/httpserver_raw; ../../../../../sam/utils/header_files; ../../../../../sam/utils/fpu; ../../../lwip-1.4.0/src/include; ../../../../../common/services/serial; ../../../lwip-port-1.4.0/sam/include/netif; ../..; ../../../../../sam/utils/cmsis/sam4e/source/templates; ../../../../../common/utils; ../../../../../sam/drivers/gmac; ../../../../../common/services/clock; ../../../../../sam/boards; ../../../../../common/utils/stdio/stdio_serial; ../../../lwip-1.4.0/src/include/lwip; ../../../../../sam/utils/cmsis/sam4e/include; ../../../lwip-1.4.0/src/include/ipv4; ../../../../../sam/drivers/uart; ..; ../../../../../sam/utils; ../../../../../sam/drivers/tc; ../../../../../sam/drivers/usart; ../../../../../common/services/serial/sam_uart; ../../../../../common/boards; ../../../lwip-port-1.4.0/sam/include; ../../../../../common/services/ioport; ../../../../../sam/boards/sam4e_ek; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: lwip_example_flash.bin
  ILINK.IlinkOutputFile: lwip_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../sam/utils/linker_scripts/sam4e/sam4e16e/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/gmac
    ../../../../../sam/drivers/gmac/: gmac.c
  group sam/drivers/uart
    ../../../../../sam/drivers/uart/: uart.c
  group sam/drivers/usart
    ../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/pmc
    ../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/tc
    ../../../../../sam/drivers/tc/: tc.c
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../sam/utils/cmsis/sam4e/source/templates/: exceptions.c system_sam4e.c
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../sam/utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/components/ethernet_phy/ksz8051mnl
    ../../../../../sam/components/ethernet_phy/ksz8051mnl/: ethernet_phy.c
  group thirdparty/lwip/lwip-1.4.0/src/core
    ../../../lwip-1.4.0/src/core/: dns.c raw.c dhcp.c memp.c netif.c lwip_timers_140.c sys.c tcp_out.c tcp_in.c udp.c pbuf.c tcp.c def.c stats.c mem.c init.c
  group thirdparty/lwip/lwip-1.4.0/src/core/ipv4
    ../../../lwip-1.4.0/src/core/ipv4/: ip.c inet.c ip_addr.c inet_chksum.c autoip.c igmp.c ip_frag.c icmp.c
  group thirdparty/lwip/lwip-1.4.0/src/api
    ../../../lwip-1.4.0/src/api/: tcpip.c sockets.c netifapi.c api_lib.c api_msg.c netbuf.c netdb.c err.c
  group thirdparty/lwip/lwip-1.4.0/src/netif
    ../../../lwip-1.4.0/src/netif/: etharp.c
  group thirdparty/lwip/example
    ../../: standalone_lwip_demo_sam.c
  group thirdparty/lwip/example/network
    ../../network/: timer_mgt_sam.c ethernet_sam.c
  group thirdparty/lwip/example/network/httpserver_raw
    ../../network/httpserver_raw/: httpd.c fs.c fsdata.c
  group thirdparty/lwip/lwip-port-1.4.0/sam/netif
    ../../../lwip-port-1.4.0/sam/netif/: ethernetif_sam4.c
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/clock/sam4e
    ../../../../../common/services/clock/sam4e/: sysclk.c
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c
