# IAR project lwip_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3X_EK; __SAM3X8H__
  ICCARM.CCIncludePath2: ../../network; ../../../../../sam/drivers/rstc; ../../../../../sam/utils/preprocessor; ../../../../../sam/components/ethernet_phy/dm9161a; ../../../../../sam/drivers/pmc; ../../../../../sam/boards/sam3x_ek; ../../network/httpserver_raw; ../../../../../sam/utils/header_files; ../../../../../sam/utils/cmsis/sam3x/source/templates; ../../../lwip-1.4.0/src/include; ../../../../../common/services/serial; ../../../lwip-port-1.4.0/sam/include/netif; ../../../../../sam/utils/cmsis/sam3x/include; ../..; ../../../../../common/utils; ../../../../../sam/drivers/emac; ../../../../../common/services/clock; ../../../../../sam/boards; ../../../../../common/utils/stdio/stdio_serial; ../../../lwip-1.4.0/src/include/lwip; ../../../../../common/services/gpio; ../../../lwip-1.4.0/src/include/ipv4; ../../../../../sam/drivers/uart; ..; ../../../../../sam/utils; ../../../../../sam/drivers/tc; ../../../../../sam/drivers/usart; ../../../../../common/services/serial/sam_uart; ../../../../../common/boards; ../../../lwip-port-1.4.0/sam/include; ../../../../../common/services/ioport; ../../../../../sam/drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM3X_EK; __SAM3X8H__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: lwip_example_flash.bin
  ILINK.IlinkOutputFile: lwip_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/lwip/example
    ../../: standalone_lwip_demo_sam.c
  group thirdparty/lwip/example/network
    ../../network/: ethernet_sam.c timer_mgt_sam.c
  group thirdparty/lwip/example/network/httpserver_raw
    ../../network/httpserver_raw/: httpd.c fs.c fsdata.c
  group thirdparty/lwip/lwip-1.4.0/src/core
    ../../../lwip-1.4.0/src/core/: raw.c init.c memp.c dhcp.c netif.c tcp.c sys.c tcp_out.c tcp_in.c udp.c pbuf.c dns.c lwip_timers_140.c def.c stats.c mem.c
  group thirdparty/lwip/lwip-1.4.0/src/core/ipv4
    ../../../lwip-1.4.0/src/core/ipv4/: igmp.c ip.c inet.c ip_addr.c inet_chksum.c autoip.c ip_frag.c icmp.c
  group thirdparty/lwip/lwip-1.4.0/src/api
    ../../../lwip-1.4.0/src/api/: tcpip.c netifapi.c api_lib.c api_msg.c sockets.c netbuf.c netdb.c err.c
  group thirdparty/lwip/lwip-1.4.0/src/netif
    ../../../lwip-1.4.0/src/netif/: etharp.c
  group thirdparty/lwip/lwip-port-1.4.0/sam/netif
    ../../../lwip-port-1.4.0/sam/netif/: ethernetif.c
  group common/services/clock/sam3x
    ../../../../../common/services/clock/sam3x/: sysclk.c
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group sam/drivers/rstc
    ../../../../../sam/drivers/rstc/: rstc.c
  group sam/drivers/uart
    ../../../../../sam/drivers/uart/: uart.c
  group sam/drivers/pio
    ../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/usart
    ../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/pmc
    ../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/tc
    ../../../../../sam/drivers/tc/: tc.c
  group sam/drivers/emac
    ../../../../../sam/drivers/emac/: emac.c
  group sam/components/ethernet_phy/dm9161a
    ../../../../../sam/components/ethernet_phy/dm9161a/: ethernet_phy.c
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../sam/utils/cmsis/sam3x/source/templates/: system_sam3x.c exceptions.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/boards/sam3x_ek
    ../../../../../sam/boards/sam3x_ek/: led.c
