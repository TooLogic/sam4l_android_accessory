# IAR project freertos_lwip_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x7000
  ICCAVR32.CCDefines: TFTP_USED=1; HTTP_USED=1; FREERTOS_USED; SMTP_USED=0; BOARD=EVK1100
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../avr32/drivers/macb; ../../network/basicsmtp; ../../../../../../avr32/boards; ../../../../../../avr32/drivers/pm; ../../../../../../avr32/drivers/flashc; ../../network/basictftp; ../../../../../lwip/lwip-1.4.0/src/include; ../../../../../../avr32/drivers/tc; ../../../../../../avr32/utils; ../../../../../../avr32/boards/evk1100; ../../../../../../avr32/drivers/gpio; ../../../../../lwip/lwip-port-1.4.0/at32uc3/include; ../../../../../../common/utils; ../../../common/include; ..; ../../../../../lwip/lwip-1.4.0/src/include/lwip; ../..; ../../../../freertos-7.0.0/source/portable/iar/avr32_uc3; ../../../../../lwip/lwip-1.4.0/src/include/ipv4; ../../../../freertos-7.0.0/source/include; ../../network/basicweb; ../../../../../../common/boards; ../../network; ../../../../../../avr32/drivers/usart; ../../../../../../avr32/components/ethernet_phy/dp83848; ../../../../../../avr32/utils/preprocessor; ../../../../../../avr32/drivers/intc; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/lwip/lwip-1.4.0/src/core
    ../../../../../lwip/lwip-1.4.0/src/core/: tcp_in.c def.c tcp_out.c stats.c lwip_timers_140.c dhcp.c sys.c mem.c dns.c pbuf.c init.c tcp.c raw.c udp.c memp.c netif.c
  group thirdparty/lwip/lwip-1.4.0/src/core/ipv4
    ../../../../../lwip/lwip-1.4.0/src/core/ipv4/: inet_chksum.c ip_frag.c autoip.c ip_addr.c igmp.c ip.c inet.c icmp.c
  group thirdparty/lwip/lwip-1.4.0/src/netif
    ../../../../../lwip/lwip-1.4.0/src/netif/: etharp.c
  group thirdparty/lwip/lwip-1.4.0/src/api
    ../../../../../lwip/lwip-1.4.0/src/api/: netbuf.c netdb.c sockets.c err.c api_msg.c tcpip.c api_lib.c netifapi.c
  group thirdparty/lwip/lwip-port-1.4.0/at32uc3
    ../../../../../lwip/lwip-port-1.4.0/at32uc3/: sys_arch.c
  group thirdparty/lwip/lwip-port-1.4.0/at32uc3/netif
    ../../../../../lwip/lwip-port-1.4.0/at32uc3/netif/: ethernetif.c
  group thirdparty/freertos/demo/lwip_avr32_uc3_example
    ../../: main.c
  group thirdparty/freertos/demo/lwip_avr32_uc3_example/network
    ../../network/: ethernet.c
  group thirdparty/freertos/demo/lwip_avr32_uc3_example/network/basictftp
    ../../network/basictftp/: BasicTFTP.c
  group thirdparty/freertos/demo/lwip_avr32_uc3_example/network/basicsmtp
    ../../network/basicsmtp/: BasicSMTP.c
  group thirdparty/freertos/demo/lwip_avr32_uc3_example/network/basicweb
    ../../network/basicweb/: BasicWEB.c
  group thirdparty/freertos/demo/lwip_avr32_uc3_example/partest
    ../../partest/: ParTest.c
  group thirdparty/freertos/demo/common/minimal
    ../../../common/minimal/: flash.c
  group thirdparty/freertos/freertos-7.0.0/source
    ../../../../freertos-7.0.0/source/: timers.c queue.c list.c croutine.c tasks.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/iar/avr32_uc3
    ../../../../freertos-7.0.0/source/portable/iar/avr32_uc3/: read.c port.c write.c exception.s82
  group thirdparty/freertos/freertos-7.0.0/source/portable/memmang
    ../../../../freertos-7.0.0/source/portable/memmang/: heap_3.c
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/intc
    ../../../../../../avr32/drivers/intc/: intc.c
  group avr32/drivers/tc
    ../../../../../../avr32/drivers/tc/: tc.c
  group avr32/drivers/pm
    ../../../../../../avr32/drivers/pm/: pm.c pm_conf_clocks.c power_clocks_lib.c
  group avr32/drivers/macb
    ../../../../../../avr32/drivers/macb/: macb.c
  group avr32/drivers/flashc
    ../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/usart
    ../../../../../../avr32/drivers/usart/: usart.c
  group avr32/boards/evk1100
    ../../../../../../avr32/boards/evk1100/: led.c
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82
