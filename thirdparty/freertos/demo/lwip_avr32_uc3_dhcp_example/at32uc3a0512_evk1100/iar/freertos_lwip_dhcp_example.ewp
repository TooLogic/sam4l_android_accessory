# IAR project freertos_lwip_dhcp_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x9000
  ICCAVR32.CCDefines: BOARD=EVK1100; HTTP_USED=1; FREERTOS_USED; TFTP_USED=1; CONFIG_INTERRUPT_FORCE_INTC; SMTP_USED=0
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../avr32/components/display/dip204; ../../../../../../avr32/drivers/macb; ../../../lwip_avr32_uc3_example/network/basicsmtp; ../../../../../../avr32/boards; ../../../../../../avr32/drivers/pm; ../../../../../../avr32/components/ethernet_phy/dp83848; ../../../lwip_avr32_uc3_example/network/basictftp; ../../../../../lwip/lwip-1.4.0/src/include; ../../../../../../avr32/drivers/tc; ../../../../../../common/services/clock; ../../../../../../avr32/utils; ../../../../../../avr32/boards/evk1100; ../../../../../../avr32/drivers/gpio; ../../../../../lwip/lwip-port-1.4.0/at32uc3/include; ../../../../freertos-7.0.0/source/portable/iar/avr32_uc3; ../../../../../../avr32/drivers/spi; ../..; ../../../common/include; ..; ../../../../../../avr32/drivers/pwm; ../../display; ../../../../../lwip/lwip-1.4.0/src/include/lwip; ../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../common/utils; ../../../../../lwip/lwip-1.4.0/src/include/ipv4; ../../../../../../common/services/delay; ../../../../freertos-7.0.0/source/include; ../../../lwip_avr32_uc3_example/network/basicweb; ../../../../../../common/boards; ../../../lwip_avr32_uc3_example/network; ../../../../../../avr32/drivers/usart; ../../../../../../avr32/drivers/flashc; ../../../../../../avr32/utils/preprocessor; ../../../../../../avr32/drivers/intc; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/lwip/lwip-1.4.0/src/core
    ../../../../../lwip/lwip-1.4.0/src/core/: dhcp.c tcp_in.c tcp_out.c def.c stats.c lwip_timers_140.c sys.c mem.c dns.c pbuf.c init.c tcp.c raw.c udp.c memp.c netif.c
  group thirdparty/lwip/lwip-1.4.0/src/core/ipv4
    ../../../../../lwip/lwip-1.4.0/src/core/ipv4/: inet_chksum.c inet.c autoip.c ip_addr.c ip_frag.c igmp.c ip.c icmp.c
  group thirdparty/lwip/lwip-1.4.0/src/netif
    ../../../../../lwip/lwip-1.4.0/src/netif/: etharp.c
  group thirdparty/lwip/lwip-1.4.0/src/api
    ../../../../../lwip/lwip-1.4.0/src/api/: api_lib.c netbuf.c netdb.c sockets.c err.c api_msg.c tcpip.c netifapi.c
  group thirdparty/lwip/lwip-port-1.4.0/at32uc3
    ../../../../../lwip/lwip-port-1.4.0/at32uc3/: sys_arch.c
  group thirdparty/lwip/lwip-port-1.4.0/at32uc3/netif
    ../../../../../lwip/lwip-port-1.4.0/at32uc3/netif/: ethernetif.c
  group thirdparty/freertos/demo/lwip_avr32_uc3_example/network/basicweb
    ../../../lwip_avr32_uc3_example/network/basicweb/: BasicWEB.c
  group thirdparty/freertos/demo/lwip_avr32_uc3_example/network/basicsmtp
    ../../../lwip_avr32_uc3_example/network/basicsmtp/: BasicSMTP.c
  group thirdparty/freertos/demo/lwip_avr32_uc3_example/network/basictftp
    ../../../lwip_avr32_uc3_example/network/basictftp/: BasicTFTP.c
  group thirdparty/freertos/demo/lwip_avr32_uc3_example/partest
    ../../../lwip_avr32_uc3_example/partest/: ParTest.c
  group thirdparty/freertos/demo/common/minimal
    ../../../common/minimal/: flash.c
  group thirdparty/freertos/demo/lwip_avr32_uc3_dhcp_example
    ../../: main.c
  group thirdparty/freertos/demo/lwip_avr32_uc3_dhcp_example/network
    ../../network/: ethernet.c
  group thirdparty/freertos/demo/lwip_avr32_uc3_dhcp_example/display
    ../../display/: display_dip204.c displayTask.c
  group thirdparty/freertos/freertos-7.0.0/source
    ../../../../freertos-7.0.0/source/: timers.c queue.c list.c croutine.c tasks.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/iar/avr32_uc3
    ../../../../freertos-7.0.0/source/portable/iar/avr32_uc3/: read.c port.c write.c exception.s82
  group thirdparty/freertos/freertos-7.0.0/source/portable/memmang
    ../../../../freertos-7.0.0/source/portable/memmang/: heap_3.c
  group avr32/drivers/pwm
    ../../../../../../avr32/drivers/pwm/: pwm.c
  group avr32/drivers/intc
    ../../../../../../avr32/drivers/intc/: intc.c
  group avr32/drivers/tc
    ../../../../../../avr32/drivers/tc/: tc.c
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/pm
    ../../../../../../avr32/drivers/pm/: pm.c pm_conf_clocks.c power_clocks_lib.c
  group avr32/drivers/macb
    ../../../../../../avr32/drivers/macb/: macb.c
  group avr32/drivers/flashc
    ../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/usart
    ../../../../../../avr32/drivers/usart/: usart.c
  group avr32/drivers/spi
    ../../../../../../avr32/drivers/spi/: spi.c
  group avr32/components/display/dip204
    ../../../../../../avr32/components/display/dip204/: dip204.c
  group avr32/boards/evk1100
    ../../../../../../avr32/boards/evk1100/: led.c
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82
  group common/services/clock/uc3a0_a1
    ../../../../../../common/services/clock/uc3a0_a1/: sysclk.c
