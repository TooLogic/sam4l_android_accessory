# IAR project freertos_peripheral_control_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3X8H__; BOARD=SAM3X_EK; UDD_ENABLE
  ICCARM.CCIncludePath2: ../../../../../../common/services/storage/ecc_hamming; ../../../../../../common/services/delay; ../../../../../../common/components/memory/sd_mmc; ../../../../../../common/services/spi/sam_spi; ../../../../../../common/services/spi; ../../../../../../common/services/storage/ctrl_access; ../../../../../../common/services/ioport; ../../../../../../common/components/memory/virtual_mem; ../../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam; ../../../../../../sam/drivers/spi; ../../../../../../sam/drivers/hsmci; ../../../../../../sam/drivers/rtc; ../../../../../../sam/drivers/dmac; ../../../../../../common/services/usb/class/cdc/device; ../../../../../../sam/utils/header_files; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/drivers/pmc; ../../../../../../sam/boards/sam3x_ek; ../../../../../../sam/utils/cmsis/sam3x/source/templates; ../../../../../../common/services/twi; ../../../../../../common/services/serial; ..; ../../../../../../sam/utils/cmsis/sam3x/include; ../../../../../../common/services/clock; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../../../common/services/usb/class/cdc; ../../../../../../common/services/freertos/sam; ../../../../freertos-7.3.0/source/include; ../../../../../../sam/boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../sam/drivers/pdc; ../../../../../../sam/drivers/tc; ../../../../../../common/services/usb; ../../demo-tasks; ../../periodic_tasks; ../../datalog-tasks; ../../../../../../common/services/gpio; ../..; ../../../../freertos-7.3.0/source/portable/iar/arm_cm3; ../../../../../../sam/drivers/uart; ../../../../../../sam/utils; ../../../../../../common/services/usb/udc; ../../../../../../sam/drivers/usart; ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../../../../../sam/drivers/pio; ../../../../../../sam/drivers/uotghs; ../../../../../../sam/drivers/twi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3X8H__; BOARD=SAM3X_EK; UDD_ENABLE
  AARM.AUserIncludes: ../../../../../../common/services/usb/class/cdc/device; ../../../../../../sam/utils/header_files; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/drivers/pmc; ../../../../../../sam/boards/sam3x_ek; ../../../../../../sam/utils/cmsis/sam3x/source/templates; ../../../../../../common/services/twi; ../../../../../../common/services/serial; ..; ../../../../../../sam/utils/cmsis/sam3x/include; ../../../../../../common/services/clock; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../../../common/services/usb/class/cdc; ../../../../../../common/services/freertos/sam; ../../../../freertos-7.3.0/source/include; ../../../../../../sam/boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../sam/drivers/pdc; ../../../../../../common/services/usb; ../../demo-tasks; ../../../../../../common/services/gpio; ../..; ../../../../freertos-7.3.0/source/portable/iar/arm_cm3; ../../../../../../sam/drivers/uart; ../../../../../../sam/utils; ../../../../../../common/services/usb/udc; ../../../../../../sam/drivers/usart; ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../../../../../sam/drivers/pio; ../../../../../../sam/drivers/uotghs; ../../../../../../sam/drivers/twi; .
  OBJCOPY.OOCOutputFile: freertos_peripheral_control_flash.bin
  ILINK.IlinkOutputFile: freertos_peripheral_control_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: as above
  group common/components/memory/sd_mmc
    ../../../../../../common/components/memory/sd_mmc/: sd_mmc.c sd_mmc_mem.c
  group common/components/memory/virtual_mem
    ../../../../../../common/components/memory/virtual_mem/: virtual_mem.c
  group common/services/clock/sam3x
    ../../../../../../common/services/clock/sam3x/: sysclk.c
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c
  group common/services/freertos/sam
    ../../../../../../common/services/freertos/sam/: freertos_peripheral_control.c freertos_twi_master.c freertos_usart_serial.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c
  group common/services/spi/sam_spi
    ../../../../../../common/services/spi/sam_spi/: spi_master.c
  group common/services/storage/ctrl_access
    ../../../../../../common/services/storage/ctrl_access/: ctrl_access.c
  group common/services/storage/ecc_hamming
    ../../../../../../common/services/storage/ecc_hamming/: ecc-sw.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: read.c write.c
  group sam/boards/sam3x_ek
    ../../../../../../sam/boards/sam3x_ek/: init.c led.c
  group sam/drivers/dmac
    ../../../../../../sam/drivers/dmac/: dmac.c
  group sam/drivers/hsmci
    ../../../../../../sam/drivers/hsmci/: hsmci.c
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/rtc
    ../../../../../../sam/drivers/rtc/: rtc.c
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/twi
    ../../../../../../sam/drivers/twi/: twi.c
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../sam/utils/cmsis/sam3x/source/templates/: exceptions.c system_sam3x.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../../../fatfs/fatfs-port-r0.09/sam/: fattime_rtc.c
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../fatfs/fatfs-r0.09/src/: ff.c
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../fatfs/fatfs-r0.09/src/option/: ccsbcs.c
  group thirdparty/freertos/demo/peripheral_control
    ../../: main.c partest.c run-time-stats-utils.c
  group thirdparty/freertos/demo/peripheral_control/datalog-tasks
    ../../datalog-tasks/: datalog_tasks.c
  group thirdparty/freertos/demo/peripheral_control/demo-tasks
    ../../demo-tasks/: CLI-commands.c USART-CLI-task.c
  group thirdparty/freertos/demo/peripheral_control/periodic_tasks
    ../../periodic_tasks/: periodic_task.c
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../freertos-7.3.0/source/: FreeRTOS_CLI.c list.c queue.c tasks.c timers.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/arm_cm3
    ../../../../freertos-7.3.0/source/portable/iar/arm_cm3/: port.c portasm.s
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../freertos-7.3.0/source/portable/memmang/: heap_4.c
