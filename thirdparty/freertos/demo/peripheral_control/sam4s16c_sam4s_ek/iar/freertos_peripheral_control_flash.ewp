# IAR project freertos_peripheral_control_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4S_EK; UDD_ENABLE; ARM_MATH_CM4=true; __SAM4S16C__
  ICCARM.CCIncludePath2: ../../../../../../common/services/usb/class/cdc/device; ../../../../../../sam/utils/header_files; ../../../../../../sam/drivers/udp; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/drivers/pmc; ../../../../../../sam/utils/cmsis/sam4s/include; ../../../../../../common/services/serial; ../../../../../../common/services/clock; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../../../common/services/usb/class/cdc; ../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../sam/boards/sam4s_ek; ../../../../../../common/services/freertos/sam; ../../../../freertos-7.3.0/source/include; ../../../../../../sam/boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../sam/drivers/pdc; ../../../../../../common/services/usb; ../../demo-tasks; ../../../../../../common/services/gpio; ../..; ../../../../freertos-7.3.0/source/portable/iar/arm_cm3; ../../../../../../sam/drivers/uart; ../../../../../../sam/utils; ../../../../../../common/services/usb/udc; ../../../../../../sam/drivers/usart; ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../../sam/drivers/pio; ..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4S_EK; UDD_ENABLE; ARM_MATH_CM4=true; __SAM4S16C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_peripheral_control_flash.bin
  ILINK.IlinkOutputFile: freertos_peripheral_control_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/clock/sam4s
    ../../../../../../common/services/clock/sam4s/: sysclk.c
  group common/services/usb/class/cdc/device
    ../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c
  group common/services/usb/udc
    ../../../../../../common/services/usb/udc/: udc.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/freertos/sam
    ../../../../../../common/services/freertos/sam/: freertos_peripheral_control.c freertos_usart_serial.c
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c
  group thirdparty/freertos/demo/peripheral_control
    ../../: partest.c run-time-stats-utils.c main.c
  group thirdparty/freertos/demo/peripheral_control/demo-tasks
    ../../demo-tasks/: USART-echo-tasks.c USB-CDC-CLI-task.c CLI-commands.c USART-CLI-task.c
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../freertos-7.3.0/source/: queue.c timers.c tasks.c list.c FreeRTOS_CLI.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/arm_cm3
    ../../../../freertos-7.3.0/source/portable/iar/arm_cm3/: port.c portasm.s
  group sam/drivers/udp
    ../../../../../../sam/drivers/udp/: udp_device.c
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c exceptions.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/boards/sam4s_ek
    ../../../../../../sam/boards/sam4s_ek/: init.c led.c
