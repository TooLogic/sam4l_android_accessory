# IAR project freertos_peripheral_control_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3U4E__; UDD_ENABLE; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../../../common/services/usb/class/cdc/device; ../../../../../../sam/utils/header_files; ../../../../../../sam/utils/cmsis/sam3u/source/templates; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/drivers/pmc; ..; ../../../../../../common/services/serial; ../../../../../../common/services/clock; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../../../common/services/usb/class/cdc; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/services/freertos/sam; ../../../../freertos-7.3.0/source/include; ../../../../../../sam/boards; ../../../../../../sam/drivers/udphs; ../../../../../../sam/boards/sam3u_ek; ../../../../../../sam/utils/cmsis/sam3u/include; ../../../../../../common/services/usb; ../../../../../../sam/drivers/pio; ../../demo-tasks; ../../../../../../common/services/gpio; ../..; ../../../../freertos-7.3.0/source/portable/iar/arm_cm3; ../../../../../../sam/drivers/uart; ../../../../../../sam/utils; ../../../../../../common/services/usb/udc; ../../../../../../sam/drivers/usart; ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../../sam/drivers/pdc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3U4E__; UDD_ENABLE; BOARD=SAM3U_EK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_peripheral_control_flash.bin
  ILINK.IlinkOutputFile: freertos_peripheral_control_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/clock/sam3u
    ../../../../../../common/services/clock/sam3u/: sysclk.c
  group common/services/usb/class/cdc/device
    ../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c
  group common/services/usb/udc
    ../../../../../../common/services/usb/udc/: udc.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/freertos/sam
    ../../../../../../common/services/freertos/sam/: freertos_peripheral_control.c freertos_usart_serial.c
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c
  group thirdparty/freertos/demo/peripheral_control
    ../../: partest.c run-time-stats-utils.c main.c
  group thirdparty/freertos/demo/peripheral_control/demo-tasks
    ../../demo-tasks/: USART-echo-tasks.c USB-CDC-CLI-task.c CLI-commands.c USART-CLI-task.c
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../freertos-7.3.0/source/: queue.c timers.c tasks.c list.c FreeRTOS_CLI.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/arm_cm3
    ../../../../freertos-7.3.0/source/portable/iar/arm_cm3/: port.c portasm.s
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../../sam/utils/cmsis/sam3u/source/templates/: system_sam3u.c exceptions.c
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c
  group sam/drivers/udphs
    ../../../../../../sam/drivers/udphs/: udphs_device.c
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c
  group sam/boards/sam3u_ek
    ../../../../../../sam/boards/sam3u_ek/: init.c led.c
