# IAR project freertos_sam_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3U4E__; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../../../common/services/serial/sam_uart; ../../../../../../sam/utils/cmsis/sam3u/source/templates; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/drivers/pmc; ../../../../../../common/services/serial; ../../../../../../common/utils; ../..; ../../../../freertos-7.0.0/source/portable/iar/sam; ../../../../../../common/services/clock; ../../../../../../sam/boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../sam/boards/sam3u_ek; ../../../../../../sam/utils/cmsis/sam3u/include; ../../../../../../common/services/gpio; ../../../../../../sam/drivers/uart; ../../../../freertos-7.0.0/source/include; ../../../../../../sam/utils; ../../../../../../sam/drivers/usart; ../../../../../../sam/utils/header_files; ../../../../../../common/boards; ../../../../../../sam/drivers/pio; ..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3U4E__; BOARD=SAM3U_EK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_sam_example_flash.bin
  ILINK.IlinkOutputFile: freertos_sam_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/clock/sam3u
    ../../../../../../common/services/clock/sam3u/: sysclk.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group thirdparty/freertos/freertos-7.0.0/source
    ../../../../freertos-7.0.0/source/: timers.c queue.c list.c croutine.c tasks.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/iar/sam
    ../../../../freertos-7.0.0/source/portable/iar/sam/: port.c portasm.s
  group thirdparty/freertos/freertos-7.0.0/source/portable/memmang
    ../../../../freertos-7.0.0/source/portable/memmang/: heap_3.c
  group thirdparty/freertos/demo/sam_example
    ../../: main.c
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../../sam/utils/cmsis/sam3u/source/templates/: system_sam3u.c exceptions.c
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/boards/sam3u_ek
    ../../../../../../sam/boards/sam3u_ek/: init.c led.c
