# IAR project fatfs_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; __SAM4S16C__; TEST_SUITE_DEFINE_ASSERT_MACRO; VIRTUAL_MEMORY_ENABLE; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  ICCARM.CCIncludePath2: ../../../../../common/services/serial/sam_uart; ../../../../../sam/utils/preprocessor; ../../../../../sam/drivers/pmc; ../../../fatfs-r0.09/src; ../../../fatfs-port-r0.09/sam; ../../../../../sam/utils/cmsis/sam4s/include; ../../../../../common/components/memory/virtual_mem; ../../../../../common/services/serial; ..; ../../../../../common/utils; ../../../../../common/services/clock; ../../../../../sam/boards; ../../../../../common/utils/stdio/stdio_serial; ../..; ../../../../../common/services/gpio; ../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../sam/drivers/uart; ../../../../../sam/utils; ../../../../../sam/drivers/usart; ../../../../../sam/utils/header_files; ../../../../../common/boards; ../../../../../sam/drivers/rtc; ../../../../../sam/drivers/pio; ../../../../../sam/boards/sam4s_xplained; ../../../../../common/services/storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: fatfs_unit_tests_flash.bin
  ILINK.IlinkOutputFile: fatfs_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c
  group common/services/clock/sam4s
    ../../../../../common/services/clock/sam4s/: sysclk.c
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/unit_test
    ../../../../../common/utils/unit_test/: suite.c
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/components/memory/virtual_mem
    ../../../../../common/components/memory/virtual_mem/: virtual_mem.c
  group sam/boards/sam4s_xplained
    ../../../../../sam/boards/sam4s_xplained/: init.c led.c
  group sam/drivers/uart
    ../../../../../sam/drivers/uart/: uart.c
  group sam/drivers/usart
    ../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/pio
    ../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/pmc
    ../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/rtc
    ../../../../../sam/drivers/rtc/: rtc.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../sam/utils/cmsis/sam4s/source/templates/: exceptions.c system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../fatfs-port-r0.09/sam/: fattime_rtc.c
  group thirdparty/fatfs/unit_tests
    ../../: unit_tests.c memories_initialization_sam.c
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../fatfs-r0.09/src/: ff.c
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../fatfs-r0.09/src/option/: ccsbcs.c
