# IAR project fatfs_unit_tests.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-f.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: _ASSERT_ENABLE_; BOARD=XMEGA_A1_XPLAINED; VIRTUAL_MEMORY_ENABLE; TEST_SUITE_DEFINE_ASSERT_MACRO; IOPORT_XMEGA_COMPAT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../xmega/drivers/pmic; ../../../../../xmega/utils; ../../../fatfs-r0.09/src; ../../../../../common/services/calendar; ../../../../../common/components/memory/virtual_mem; ../../../../../common/services/serial; ../../../../../common/services/ioport; ../../../../../common/services/serial/xmega_usart; ../../../../../xmega/drivers/usart; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../../xmega/drivers/ebi; ../../../../../common/services/clock; ../../../../../common/utils/stdio/stdio_serial; ../../../../../xmega/boards/xmega_a1_xplained; ../../../fatfs-port-r0.09/xmega; ../../../../../xmega/boards; ../..; ../../../../../common/services/gpio; ..; ../../../../../common/boards; ../../../../../xmega/drivers/rtc; ../../../../../common/services/hugemem; ../../../../../xmega/utils/preprocessor; ../../../../../xmega/drivers/sleep; ../../../../../xmega/drivers/cpu; ../../../../../common/services/storage/ctrl_access; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: as above
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _ASSERT_ENABLE_; BOARD=XMEGA_A1_XPLAINED; VIRTUAL_MEMORY_ENABLE; TEST_SUITE_DEFINE_ASSERT_MACRO; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: lnk0t.xcl
  group common/services/hugemem/avr8
    ../../../../../common/services/hugemem/avr8/: avr8_hugemem.c
  group common/services/sleepmgr/xmega
    ../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/calendar
    ../../../../../common/services/calendar/: calendar.c
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c
  group common/services/clock/xmega
    ../../../../../common/services/clock/xmega/: sysclk.c
  group common/services/ioport/xmega
    ../../../../../common/services/ioport/xmega/: ioport_compat.c
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c
  group common/components/memory/virtual_mem
    ../../../../../common/components/memory/virtual_mem/: virtual_mem.c
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../common/utils/unit_test/: suite.c
  group thirdparty/fatfs/unit_tests
    ../../: unit_tests.c memories_initialization_xmega.c
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../fatfs-r0.09/src/: ff.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/xmega
    ../../../fatfs-port-r0.09/xmega/: fattime.c
  group xmega/drivers/rtc
    ../../../../../xmega/drivers/rtc/: rtc.c
  group xmega/drivers/ebi
    ../../../../../xmega/drivers/ebi/: ebi.c
  group xmega/drivers/usart
    ../../../../../xmega/drivers/usart/: usart.c
  group xmega/drivers/cpu
    ../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xmega_a1_xplained
    ../../../../../xmega/boards/xmega_a1_xplained/: init.c
