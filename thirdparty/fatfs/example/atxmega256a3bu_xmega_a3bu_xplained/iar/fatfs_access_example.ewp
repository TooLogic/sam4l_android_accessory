# IAR project fatfs_access_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: AT45DBX_ENABLE; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../xmega/drivers/pmic; ../../../../../common/services/spi/xmega_spi; ..; ../../../../../common/components/memory/data_flash/at45dbx; ../../../../../xmega/utils; ../../../fatfs-r0.09/src; ../../../../../common/services/calendar; ../../../../../common/services/serial; ../../../../../common/services/ioport; ../../../../../common/services/serial/xmega_usart; ../../../../../xmega/drivers/usart; ../../../../../xmega/drivers/nvm; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../../xmega/drivers/rtc32; ../../../../../common/utils/stdio/stdio_serial; ../../../../../common/services/clock; ../..; ../../../../../xmega/boards/xmega_a3bu_xplained; ../../../fatfs-port-r0.09/xmega; ../../../../../xmega/boards; ../../../../../common/services/gpio; ../../../../../common/services/delay; ../../../../../common/services/hugemem; ../../../../../common/services/spi; ../../../../../common/boards; ../../../../../xmega/drivers/spi; ../../../../../xmega/utils/preprocessor; ../../../../../xmega/drivers/sleep; ../../../../../xmega/drivers/cpu; ../../../../../common/services/storage/ctrl_access; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; AT45DBX_ENABLE; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c
  group common/services/spi/xmega_spi
    ../../../../../common/services/spi/xmega_spi/: spi_master.c
  group common/services/spi/xmega_usart_spi
    ../../../../../common/services/spi/xmega_usart_spi/: usart_spi.c
  group common/services/sleepmgr/xmega
    ../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/clock/xmega
    ../../../../../common/services/clock/xmega/: sysclk.c
  group common/services/hugemem/avr8
    ../../../../../common/services/hugemem/avr8/: avr8_hugemem.c
  group common/services/calendar
    ../../../../../common/services/calendar/: calendar.c
  group common/services/ioport/xmega
    ../../../../../common/services/ioport/xmega/: ioport_compat.c
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/components/memory/data_flash/at45dbx
    ../../../../../common/components/memory/data_flash/at45dbx/: at45dbx.c at45dbx_mem.c
  group xmega/drivers/spi
    ../../../../../xmega/drivers/spi/: spi.c
  group xmega/drivers/nvm
    ../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/usart
    ../../../../../xmega/drivers/usart/: usart.c
  group xmega/drivers/rtc32
    ../../../../../xmega/drivers/rtc32/: rtc32.c
  group xmega/drivers/cpu
    ../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../xmega/boards/xmega_a3bu_xplained/: init.c
  group thirdparty/fatfs/example
    ../../: fatfs_access_example.c memories_initialization_xmega.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/xmega
    ../../../fatfs-port-r0.09/xmega/: fattime.c
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../fatfs-r0.09/src/: ff.c
