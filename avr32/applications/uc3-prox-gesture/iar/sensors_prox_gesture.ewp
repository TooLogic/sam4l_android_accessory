# IAR project sensors_prox_gesture.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: EXT_BOARD=SENSORS_XPLAINED_LIGHTPROX_1; BOARD=UC3_L0_XPLAINED; CONF_STDIO_REDIRECT
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../drivers/scif; ../../../../common/services/sensors; ../../../boards; ../../../drivers/twim; ../conf; ../../../drivers/pm; ../../../drivers/eic; ../../../../common/services/serial; ../../../utils; ../../../drivers/gpio; ../../../../common/services/sleepmgr; ../../../drivers/flashcdw; ../../../../common/services/clock; ../../../../common/utils/stdio/stdio_serial; ../../../drivers/cpu/cycle_counter; ../../../../common/utils; ../../../drivers/intc; ../../../../common/services/twi; ../../../../common/services/delay; ../../../../common/services/serial/uc3_usart; ../../../../common/boards; ../../../drivers/usart; ../../../utils/preprocessor; ../../../boards/uc3_l0_xplained; ../../../../common/services/sensors/module_config; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/eic
    ../../../drivers/eic/: eic.c
  group avr32/drivers/flashcdw
    ../../../drivers/flashcdw/: flashcdw.c
  group avr32/drivers/pm
    ../../../drivers/pm/: pm_uc3l.c power_clocks_lib.c
  group avr32/drivers/intc
    ../../../drivers/intc/: intc.c exception.s82
  group avr32/drivers/gpio
    ../../../drivers/gpio/: gpio.c
  group avr32/drivers/twim
    ../../../drivers/twim/: twim.c
  group avr32/drivers/usart
    ../../../drivers/usart/: usart.c
  group avr32/drivers/scif
    ../../../drivers/scif/: scif_uc3l.c
  group avr32/boards/uc3_l0_xplained
    ../../../boards/uc3_l0_xplained/: led.c init.c
  group avr32/utils/startup
    ../../../utils/startup/: trampoline_uc3.s82
  group common/services/sensors
    ../../../../common/services/sensors/: sensor.c sensor_nvram.c sensor_platform.c sensor_bus.c
  group common/services/sensors/drivers/bosch
    ../../../../common/services/sensors/drivers/bosch/: bma150.c bma020.c bma250.c bma_axis.inc.c bma222.c bma180.c bma220.c bmp.c
  group common/services/sensors/drivers/invensense
    ../../../../common/services/sensors/drivers/invensense/: itg3200.c imu3000.c
  group common/services/sensors/drivers/akm
    ../../../../common/services/sensors/drivers/akm/: ak8975.c
  group common/services/sensors/drivers/osram
    ../../../../common/services/sensors/drivers/osram/: sfh5712.c sfh7770.c
  group common/services/sensors/drivers/kionix
    ../../../../common/services/sensors/drivers/kionix/: kxtf9.c
  group common/services/sensors/drivers/honeywell
    ../../../../common/services/sensors/drivers/honeywell/: hmc5883l.c
  group common/services/sensors/physics
    ../../../../common/services/sensors/physics/: physics.c
  group common/services/clock/uc3l
    ../../../../common/services/clock/uc3l/: dfll.c sysclk.c osc.c
  group common/services/sleepmgr/uc3
    ../../../../common/services/sleepmgr/uc3/: sleepmgr.c
  group common/services/serial
    ../../../../common/services/serial/: usart_serial.c
  group common/utils/stdio
    ../../../../common/utils/stdio/: read.c write.c
  group common/boards/sensors_xplained
    ../../../../common/boards/sensors_xplained/: sensors_xplained.c
  group common/applications/sensors/prox_gesture
    ../../../../common/applications/sensors/prox_gesture/: main.c
