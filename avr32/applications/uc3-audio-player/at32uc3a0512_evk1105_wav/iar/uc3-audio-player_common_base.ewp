# IAR project uc3-audio-player_common_base.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0xD41C
  ICCAVR32.CCDefines: BOARD=EVK1105; CONFIG_INTERRUPT_FORCE_INTC; ACCESS_MEM_TO_RAM_ENABLED; SD_MMC_SPI_ENABLE; AT45DBX_ENABLE
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../services/audio/audio_player/ai_usb_ms; ../../../../services/usb/_asf_v1/class/mass_storage/scsi_decoder; ../../../../drivers/ssc/i2s; ../../../../services/fs/fat; ../../../../components/memory/sd_mmc/sd_mmc_spi; ../../../../drivers/ebi/sdramc; ../../../../boards; ../../../../drivers/pdca; ../../../../components/audio; ../../user_interface/gui; ../../../../drivers/pm; ../../../../services/audio/audio_mixer; ../../../../components/audio/amp/tpa6130a2; ../../../../components/display/et024006dhu; ../../../../services/usb/_asf_v1; ../../../../services/audio/audio_player; ../../../../drivers/usbb/_asf_v1; ../../../../services/usb/_asf_v1/class/mass_storage/host_mem; ../../../../services/audio/audio_player/ai_sd_mmc; ../../../../boards/evk1105; ../../../../utils; ../../../../drivers/gpio; ../../../../components/touch/qt1081; ../../../../components/audio/codec/tlv320aic23b; ../../../../drivers/wdt; ../../../../services/audio/audio_player/players/wav; ../../../../drivers/spi; ../..; ..; ../../conf; ../../../../components/audio/dac/pwm_dac; ../../../../drivers/cpu/cycle_counter; ../../../../../common/utils; ../../../../drivers/usbb/_asf_v1/enum; ../../../../components/memory/sdram; ../../clocks; ../../../../drivers/abdac; ../../../../services/audio/wav; ../../../../drivers/ebi/smc; ../../user_interface/controller; ../../../../../common/boards; ../../../../../common/components/memory/data_flash/at45dbx/_asf_v1; ../../../../services/audio/audio_player/players; ../../../../drivers/flashc; ../../../../drivers/twi; ../../../../utils/preprocessor; ../../../../drivers/intc; ../../../../../thirdparty/dlmalloc; ../../../../../thirdparty/newlib_addons/libs/include; ../../../../../common/services/storage/ctrl_access; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 2
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/services/fs/fat
    ../../../../services/fs/fat/: reader_txt.c navigation.c unicode.c play_list.c file.c nav_filterlist.c fat_unusual.c fat.c
  group avr32/services/audio/wav
    ../../../../services/audio/wav/: wavdecode.c
  group avr32/services/audio/audio_mixer
    ../../../../services/audio/audio_mixer/: audio_mixer.c
  group avr32/services/audio/audio_player
    ../../../../services/audio/audio_player/: audio_interface.c
  group avr32/services/audio/audio_player/ai_usb_ms
    ../../../../services/audio/audio_player/ai_usb_ms/: ai_usb_ms.c host_mass_storage_task.c ai_usb_ms_wav_support.c
  group avr32/services/audio/audio_player/players
    ../../../../services/audio/audio_player/players/: buff_player.c
  group avr32/services/audio/audio_player/players/wav
    ../../../../services/audio/audio_player/players/wav/: wav_player.c
  group avr32/services/audio/audio_player/ai_sd_mmc
    ../../../../services/audio/audio_player/ai_sd_mmc/: ai_sd_mmc.c
  group avr32/services/usb/_asf_v1/class/mass_storage/host_mem
    ../../../../services/usb/_asf_v1/class/mass_storage/host_mem/: host_mem.c
  group avr32/services/usb/_asf_v1/class/mass_storage/scsi_decoder
    ../../../../services/usb/_asf_v1/class/mass_storage/scsi_decoder/: scsi_decoder.c
  group avr32/drivers/ssc/i2s
    ../../../../drivers/ssc/i2s/: ssc_i2s.c
  group avr32/drivers/wdt
    ../../../../drivers/wdt/: wdt.c
  group avr32/drivers/pdca
    ../../../../drivers/pdca/: pdca.c
  group avr32/drivers/usbb/_asf_v1
    ../../../../drivers/usbb/_asf_v1/: usb_drv.c
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c
  group avr32/drivers/twi
    ../../../../drivers/twi/: twi.c
  group avr32/drivers/pm
    ../../../../drivers/pm/: pm_conf_clocks.c pm.c power_clocks_lib.c
  group avr32/drivers/ebi/smc
    ../../../../drivers/ebi/smc/: smc.c
  group avr32/drivers/ebi/sdramc
    ../../../../drivers/ebi/sdramc/: sdramc.c
  group avr32/drivers/abdac
    ../../../../drivers/abdac/: abdac.c
  group avr32/drivers/flashc
    ../../../../drivers/flashc/: flashc.c
  group avr32/drivers/intc
    ../../../../drivers/intc/: intc.c exception.s82
  group avr32/drivers/spi
    ../../../../drivers/spi/: spi.c
  group avr32/components/display/et024006dhu
    ../../../../components/display/et024006dhu/: et024006dhu.c
  group avr32/components/memory/sd_mmc/sd_mmc_spi
    ../../../../components/memory/sd_mmc/sd_mmc_spi/: sd_mmc_spi_mem.c sd_mmc_spi.c
  group avr32/components/audio/amp/tpa6130a2
    ../../../../components/audio/amp/tpa6130a2/: tpa6130.c
  group avr32/components/audio/codec/tlv320aic23b
    ../../../../components/audio/codec/tlv320aic23b/: tlv320aic23b.c
  group avr32/components/audio/dac/pwm_dac
    ../../../../components/audio/dac/pwm_dac/: pwm_dac.c
  group avr32/applications/uc3-audio-player
    ../../: usb_host_task.c usb_host_enum.c usb_task.c com_task.c main.c nav_automatic.c codec_wav_task.c
  group avr32/applications/uc3-audio-player/clocks
    ../../clocks/: clocks_fosc0_12000000_fosc1_11289600.c
  group avr32/applications/uc3-audio-player/user_interface/gui
    ../../user_interface/gui/: et024006dhu_gui.c sdram_loader.c
  group avr32/applications/uc3-audio-player/user_interface/controller
    ../../user_interface/controller/: joystick_controller.c
  group avr32/boards/evk1105
    ../../../../boards/evk1105/: led.c
  group avr32/utils/startup
    ../../../../utils/startup/: trampoline_uc3.s82
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c
  group common/components/memory/data_flash/at45dbx/_asf_v1
    ../../../../../common/components/memory/data_flash/at45dbx/_asf_v1/: at45dbx_mem.c at45dbx.c
  group thirdparty/dlmalloc
    ../../../../../thirdparty/dlmalloc/: dlmalloc.c dlsbrk.c
  group thirdparty/dlmalloc/portable/iar/avr32_uc3
    ../../../../../thirdparty/dlmalloc/portable/iar/avr32_uc3/: syscalls.c
