# IAR project uc3-audio-player_common_base.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0xD41C
  ICCAVR32.CCDefines: SD_MMC_MCI_ENABLE; BOARD=EVK1104; CONFIG_INTERRUPT_FORCE_INTC; ACCESS_MEM_TO_RAM_ENABLED; AT45DBX_ENABLE
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../services/audio/audio_player/ai_usb_ms; ../../../../services/usb/_asf_v1/class/mass_storage/scsi_decoder; ../../../../drivers/ssc/i2s; ../../../../../thirdparty/libmad/libs/include; ../../../../services/fs/fat; ../../../../services/audio/mp3/id3; ../../../../../thirdparty/ijg/libs/jpg_ijg_without_mm/include; ../../../../drivers/ebi/sdramc; ../../../../boards; ../../../../drivers/pdca; ../../../../components/audio; ../../user_interface/gui; ../../../../drivers/twim; ../../../../drivers/pm; ../../../../services/audio/audio_mixer; ../../../../components/audio/amp/tpa6130a2; ../../../../components/touch/qt60168; ../../../../components/display/et024006dhu; ../../../../services/usb/_asf_v1; ../../../../services/audio/audio_player; ../../../../drivers/usbb/_asf_v1; ../../../../services/usb/_asf_v1/class/mass_storage/host_mem; ../../../../drivers/mci/_asf_v1; ../../../../services/audio/audio_player/ai_sd_mmc; ../../../../boards/evk1104; ../../../../drivers/rtc; ../../../../drivers/gpio; ../../../../../common/utils; ../../../../services/audio/audio_player/players/mp3; ../../../../drivers/spi; ../..; ../../../../utils; ../../jpg; ../../conf; ../../../../drivers/cpu/cycle_counter; ../../../../drivers/wdt; ../../../../drivers/usbb/_asf_v1/enum; ../../../../components/memory/sdram; ../../clocks; ../../../../drivers/abdac; ../../../../drivers/ebi/smc; ../../user_interface/controller; ../../../../../common/boards; ../../../../../common/components/memory/data_flash/at45dbx/_asf_v1; ../../../../drivers/usart; ../../../../drivers/flashc; ../../../../utils/preprocessor; ../../../../utils/debug; ..; ../../../../drivers/intc; ../../../../../thirdparty/dlmalloc; ../../../../components/memory/sd_mmc/sd_mmc_mci; ../../../../../thirdparty/newlib_addons/libs/include; ../../../../../common/services/storage/ctrl_access; ../../../../services/audio/audio_player/players; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 2
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/libmad/libs/at32ucr2/iar
    ../../../../../thirdparty/libmad/libs/at32ucr2/iar/: libmad-at32ucr2-speed_opt.r82
  group thirdparty/ijg/libs/jpg_ijg_without_mm/at32ucr2/iar
    ../../../../../thirdparty/ijg/libs/jpg_ijg_without_mm/at32ucr2/iar/: libjpg_ijg_without_mm-at32ucr2-speed_opt.r82
  group thirdparty/dlmalloc
    ../../../../../thirdparty/dlmalloc/: dlmalloc.c dlsbrk.c
  group thirdparty/dlmalloc/portable/iar/avr32_uc3
    ../../../../../thirdparty/dlmalloc/portable/iar/avr32_uc3/: syscalls.c
  group avr32/services/fs/fat
    ../../../../services/fs/fat/: reader_txt.c navigation.c unicode.c file.c nav_filterlist.c fat_unusual.c fat.c play_list.c
  group avr32/services/audio/audio_mixer
    ../../../../services/audio/audio_mixer/: audio_mixer.c
  group avr32/services/audio/audio_player
    ../../../../services/audio/audio_player/: audio_interface.c
  group avr32/services/audio/audio_player/players
    ../../../../services/audio/audio_player/players/: buff_player.c
  group avr32/services/audio/audio_player/players/mp3
    ../../../../services/audio/audio_player/players/mp3/: mp3_libmad_player.c
  group avr32/services/audio/audio_player/ai_usb_ms
    ../../../../services/audio/audio_player/ai_usb_ms/: ai_usb_ms.c ai_usb_ms_mp3_support.c host_mass_storage_task.c
  group avr32/services/audio/audio_player/ai_sd_mmc
    ../../../../services/audio/audio_player/ai_sd_mmc/: ai_sd_mmc.c
  group avr32/services/audio/mp3/id3
    ../../../../services/audio/mp3/id3/: reader_id3.c
  group avr32/services/usb/_asf_v1/class/mass_storage/host_mem
    ../../../../services/usb/_asf_v1/class/mass_storage/host_mem/: host_mem.c
  group avr32/services/usb/_asf_v1/class/mass_storage/scsi_decoder
    ../../../../services/usb/_asf_v1/class/mass_storage/scsi_decoder/: scsi_decoder.c
  group avr32/drivers/ssc/i2s
    ../../../../drivers/ssc/i2s/: ssc_i2s.c
  group avr32/drivers/pm
    ../../../../drivers/pm/: pm.c power_clocks_lib.c pm_conf_clocks.c
  group avr32/drivers/wdt
    ../../../../drivers/wdt/: wdt.c
  group avr32/drivers/rtc
    ../../../../drivers/rtc/: rtc.c
  group avr32/drivers/pdca
    ../../../../drivers/pdca/: pdca.c
  group avr32/drivers/usbb/_asf_v1
    ../../../../drivers/usbb/_asf_v1/: usb_drv.c
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c
  group avr32/drivers/usart
    ../../../../drivers/usart/: usart.c
  group avr32/drivers/abdac
    ../../../../drivers/abdac/: abdac.c
  group avr32/drivers/ebi/smc
    ../../../../drivers/ebi/smc/: smc.c
  group avr32/drivers/ebi/sdramc
    ../../../../drivers/ebi/sdramc/: sdramc.c
  group avr32/drivers/mci/_asf_v1
    ../../../../drivers/mci/_asf_v1/: mci.c
  group avr32/drivers/twim
    ../../../../drivers/twim/: twim.c
  group avr32/drivers/flashc
    ../../../../drivers/flashc/: flashc.c
  group avr32/drivers/intc
    ../../../../drivers/intc/: intc.c exception.s82
  group avr32/drivers/spi
    ../../../../drivers/spi/: spi.c
  group avr32/components/display/et024006dhu
    ../../../../components/display/et024006dhu/: et024006dhu.c
  group avr32/components/touch/qt60168
    ../../../../components/touch/qt60168/: qt60168.c
  group avr32/components/memory/sd_mmc/sd_mmc_mci
    ../../../../components/memory/sd_mmc/sd_mmc_mci/: sd_mmc_mci.c sd_mmc_mci_mem.c
  group avr32/components/audio/amp/tpa6130a2
    ../../../../components/audio/amp/tpa6130a2/: tpa6130.c
  group avr32/boards/evk1104
    ../../../../boards/evk1104/: led.c
  group avr32/applications/uc3-audio-player
    ../../: main.c usb_host_task.c usb_host_enum.c codec_mp3_task.c usb_task.c com_task.c nav_automatic.c
  group avr32/applications/uc3-audio-player/jpg
    ../../jpg/: jmemsdram.c jdatasrc.c
  group avr32/applications/uc3-audio-player/user_interface/gui
    ../../user_interface/gui/: et024006dhu_gui.c sdram_loader.c
  group avr32/applications/uc3-audio-player/user_interface/controller
    ../../user_interface/controller/: qt60168_controller.c
  group avr32/applications/uc3-audio-player/clocks
    ../../clocks/: clocks_fosc0_12000000_fosc1_11289600.c
  group avr32/utils/debug
    ../../../../utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../utils/startup/: trampoline_uc3.s82
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c
  group common/components/memory/data_flash/at45dbx/_asf_v1
    ../../../../../common/components/memory/data_flash/at45dbx/_asf_v1/: at45dbx_mem.c at45dbx.c
