# IAR project rz600-uc3a-wireless-uart.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=RZ600; UDD_ENABLE; UDD_NO_SLEEP_MGR; EXT_BOARD=RZ600_AT86RF230B
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../common/services/usb/class/cdc/device; ../../../../../common/components/wireless; ../../../../boards; ../../../../../common/services/spi/uc3_spi; ../../../../drivers/usbb; ../../../../drivers/pm; ../../../../utils; ../../../../drivers/gpio; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../boards/rz600; ../../../../drivers/spi; ../../../../../common/services/usb/class/cdc; ../../../../../common/services/clock; ../../../../../common/services/usb/udc; ../../../../../common/services/usb; ../../../../drivers/cpu/cycle_counter; ../../../../../common/services/spi; ../../../../../common/boards; ../../../../drivers/flashc; ../..; ../../../../utils/preprocessor; ../../../../drivers/intc; ../../conf; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../utils/linker_scripts/at32uc3a3/256s/iar/lnkuc3a3256s.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/usb/class/cdc/device
    ../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c
  group common/services/usb/udc
    ../../../../../common/services/usb/udc/: udc.c
  group common/services/sleepmgr/uc3
    ../../../../../common/services/sleepmgr/uc3/: sleepmgr.c
  group common/services/spi/uc3_spi
    ../../../../../common/services/spi/uc3_spi/: spi_master.c
  group common/services/clock/uc3a3_a4
    ../../../../../common/services/clock/uc3a3_a4/: sysclk.c
  group common/components/wireless
    ../../../../../common/components/wireless/: at86rfx_driver.c
  group common/components/wireless/at86rf230b
    ../../../../../common/components/wireless/at86rf230b/: at86rf230b.c
  group avr32/drivers/pm
    ../../../../drivers/pm/: power_clocks_lib.c pm.c pm_conf_clocks.c
  group avr32/drivers/usbb
    ../../../../drivers/usbb/: usbb_device.c
  group avr32/drivers/flashc
    ../../../../drivers/flashc/: flashc.c
  group avr32/drivers/intc
    ../../../../drivers/intc/: intc.c exception.s82
  group avr32/drivers/spi
    ../../../../drivers/spi/: spi.c
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c
  group avr32/boards/rz600
    ../../../../boards/rz600/: led.c init.c
  group avr32/applications/rz600-uc3a-wireless-uart
    ../../: main.c
  group avr32/utils/startup
    ../../../../utils/startup/: trampoline_uc3.s82
