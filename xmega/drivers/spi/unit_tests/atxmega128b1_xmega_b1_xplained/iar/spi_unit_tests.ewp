# IAR project spi_unit_tests.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128b1 ATxmega128B1
  ICCAVR.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../boards/xmega_b1_xplained; ../../../../../../common/services/serial; ../../../../../utils/preprocessor; ../../../../pmic; ../../../../../../common/services/clock; ../../../../../../common/services/gpio; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/boards; ../../../../../../common/services/serial/xmega_usart; ../../../../../utils; ../../..; ..; ../../../../usart; ../..; ../../../../../boards; ../../../../nvm; ../../../../../../common/utils; ../../../../cpu; ../../../../../../common/services/ioport; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c
  group common/services/clock/xmega
    ../../../../../../common/services/clock/xmega/: sysclk.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/ioport/xmega
    ../../../../../../common/services/ioport/xmega/: ioport_compat.c
  group xmega/boards/xmega_b1_xplained
    ../../../../../boards/xmega_b1_xplained/: init.c
  group xmega/drivers/spi
    ../../../: spi.c
  group xmega/drivers/spi/unit_tests
    ../../: unit_tests.c
  group xmega/drivers/nvm
    ../../../../nvm/: nvm.c nvm_asm.s
  group xmega/drivers/usart
    ../../../../usart/: usart.c
  group xmega/drivers/cpu
    ../../../../cpu/: ccp.s
