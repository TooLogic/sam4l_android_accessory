# IAR project nvm_example1.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm32d4 ATxmega32D4
  ICCAVR.CCDefines: BOARD=STK600_RC044X; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ..; ../../../../../../common/services/clock; ../../../../cpu; ../../../../../../common/boards; ../../../../../utils/preprocessor; ../../../../../utils; ../../../../../boards/stk600/rc044x; ../../../../../../common/services/ioport; ../../../../../boards; ../../..; ../../../../../../common/utils; ../../../../../../common/services/gpio; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=STK600_RC044X; IOPORT_XMEGA_COMPAT
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_RC044X; IOPORT_XMEGA_COMPAT
  group xmega/boards/stk600/rc044x
    ../../../../../boards/stk600/rc044x/: init.c
  group xmega/drivers/nvm
    ../../../: nvm.c nvm_asm.s
  group xmega/drivers/nvm/example1
    ../../: example1_xmega.c
  group xmega/drivers/cpu
    ../../../../cpu/: ccp.s
  group common/services/ioport/xmega
    ../../../../../../common/services/ioport/xmega/: ioport_compat.c
  group common/services/clock/xmega
    ../../../../../../common/services/clock/xmega/: sysclk.c
