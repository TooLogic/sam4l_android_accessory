# IAR project wdt_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm32a4u ATxmega32A4U
  ICCAVR.CCDefines: BOARD=STK600_RC044X; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../common/services/delay; ..; ../../../../../../common/services/clock; ../../../../../../common/services/gpio; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../utils; ../../../../../boards/stk600/rc044x; ../../../../../utils/preprocessor; ../../..; ../../../../../boards; ../../../../nvm; ../../../../../../common/utils; ../../../../cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=STK600_RC044X; IOPORT_XMEGA_COMPAT
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_RC044X; IOPORT_XMEGA_COMPAT
  group xmega/boards/stk600/rc044x
    ../../../../../boards/stk600/rc044x/: init.c
  group xmega/drivers/wdt
    ../../../: wdt.c
  group xmega/drivers/wdt/example
    ../../: wdt_example.c
  group xmega/drivers/nvm
    ../../../../nvm/: nvm.c nvm_asm.s
  group xmega/drivers/cpu
    ../../../../cpu/: ccp.s
  group common/services/clock/xmega
    ../../../../../../common/services/clock/xmega/: sysclk.c
  group common/services/ioport/xmega
    ../../../../../../common/services/ioport/xmega/: ioport_compat.c
