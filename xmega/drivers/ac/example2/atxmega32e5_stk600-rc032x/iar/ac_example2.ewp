# IAR project ac_example2.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm32e5 ATxmega32E5
  ICCAVR.CCDefines: BOARD=STK600_RC032X; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../boards/stk600/rc032x; ../../../../../boards; ../../../../pmic; ../../../../../../common/services/clock; ../../../../cpu; ../../../../../../common/boards; ../../..; ../../../../../utils; ../../../../../utils/preprocessor; ..; ../../../../../../common/utils; ../../../../../../common/services/sleepmgr; ../../../../sleep; ../../../../../../common/services/gpio; ../../../../../../common/services/ioport; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=STK600_RC032X; IOPORT_XMEGA_COMPAT
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_RC032X; IOPORT_XMEGA_COMPAT
  group common/services/clock/xmega
    ../../../../../../common/services/clock/xmega/: sysclk.c
  group common/services/ioport/xmega
    ../../../../../../common/services/ioport/xmega/: ioport_compat.c
  group common/services/sleepmgr/xmega
    ../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group xmega/drivers/ac
    ../../../: ac.c
  group xmega/drivers/ac/example2
    ../../: ac_example2.c
  group xmega/drivers/cpu
    ../../../../cpu/: ccp.s
  group xmega/boards/stk600/rc032x
    ../../../../../boards/stk600/rc032x/: init.c
