# IAR project aes_example3.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=XPLAIN; IOPORT_XMEGA_COMPAT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ..; ../../../../pmic; ../../../../../../common/services/clock; ../../../../../../common/services/gpio; ../..; ../../../../../../common/services/ioport; ../../../../../../common/boards; ../../../../../utils; ../../../../dma; ../../../../../../common/services/hugemem; ../../../../../utils/preprocessor; ../../..; ../../../../../boards; ../../../../../../common/utils; ../../../../../../common/services/sleepmgr; ../../../../sleep; ../../../../../boards/xplain; ../../../../cpu; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: BOARD=XPLAIN; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XPLAIN; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: lnk0t.xcl
  group xmega/drivers/aes
    ../../../: aes.c
  group xmega/drivers/aes/example3
    ../../: aes_example3.c
  group xmega/drivers/dma
    ../../../../dma/: dma.c
  group xmega/drivers/cpu
    ../../../../cpu/: ccp.s
  group xmega/boards/xplain
    ../../../../../boards/xplain/: init.c
  group common/services/clock/xmega
    ../../../../../../common/services/clock/xmega/: sysclk.c
  group common/services/hugemem/avr8
    ../../../../../../common/services/hugemem/avr8/: avr8_hugemem.c
  group common/services/sleepmgr/xmega
    ../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/ioport/xmega
    ../../../../../../common/services/ioport/xmega/: ioport_compat.c
