# IAR project aes_example3.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../..; ../../../../../../common/services/sleepmgr; ../../../../pmic; ../../../../../boards/xmega_a3bu_xplained; ../../../../../../common/services/clock; ../../../../../../common/services/gpio; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../utils; ../../../../dma; ../../../../../../common/services/hugemem; ../../../../../utils/preprocessor; ../../..; ../../../../../../common/utils; ../../../../../boards; ../../../../nvm; ..; ../../../../sleep; ../../../../cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  group xmega/drivers/aes
    ../../../: aes.c
  group xmega/drivers/aes/example3
    ../../: aes_example3.c
  group xmega/drivers/nvm
    ../../../../nvm/: nvm.c nvm_asm.s
  group xmega/drivers/dma
    ../../../../dma/: dma.c
  group xmega/drivers/cpu
    ../../../../cpu/: ccp.s
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../boards/xmega_a3bu_xplained/: init.c
  group common/services/clock/xmega
    ../../../../../../common/services/clock/xmega/: sysclk.c
  group common/services/hugemem/avr8
    ../../../../../../common/services/hugemem/avr8/: avr8_hugemem.c
  group common/services/sleepmgr/xmega
    ../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/ioport/xmega
    ../../../../../../common/services/ioport/xmega/: ioport_compat.c
