# IAR project aes_unit_tests.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm384c3 ATxmega384C3
  ICCAVR.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=STK600_RC064X; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../usart; ../../../../../../common/services/serial; ../../../../../boards; ../../../../pmic; ../../../../../../common/utils; ../../../../../../common/services/clock; ../../../../cpu; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/boards; ../../../../../utils/preprocessor; ../../../../../boards/stk600/rc064x; ../../../../../utils; ../../../../../../common/services/serial/xmega_usart; ../../..; ../..; ..; ../../../../nvm; ../../../../../../common/services/sleepmgr; ../../../../sleep; ../../../../../../common/services/gpio; ../../../../../../common/services/ioport; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=STK600_RC064X; IOPORT_XMEGA_COMPAT
  group xmega/drivers/aes
    ../../../: aes.c
  group xmega/drivers/aes/unit_tests
    ../../: unit_tests.c
  group xmega/drivers/nvm
    ../../../../nvm/: nvm.c nvm_asm.s
  group xmega/drivers/usart
    ../../../../usart/: usart.c
  group xmega/drivers/cpu
    ../../../../cpu/: ccp.s
  group xmega/boards/stk600/rc064x
    ../../../../../boards/stk600/rc064x/: init.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c
  group common/services/ioport/xmega
    ../../../../../../common/services/ioport/xmega/: ioport_compat.c
  group common/services/sleepmgr/xmega
    ../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/xmega
    ../../../../../../common/services/clock/xmega/: sysclk.c
