# IAR project edma_example_1.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm32e5 ATxmega32E5
  ICCAVR.CCDefines: BOARD=XMEGA_E5_XPLAINED; GFX_MONO_UG_2832HSWEG04=1; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../common/services/delay; ../../../../pmic; ../../..; ../../../../../../common/services/clock; ../../../../cpu; ../../../../../../common/services/spi; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../utils; ../../../../../../common/services/gfx_mono; ../../../../../../common/services/sleepmgr; ..; ../../../../usart; ../../../../../../common/components/display/ssd1306; ../../../../../boards; ../../../../../../common/utils; ../../../../../utils/preprocessor; ../../../../sleep; ../../../../../../common/services/gpio; ../../../../../boards/xmega_e5_xplained; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_E5_XPLAINED; GFX_MONO_UG_2832HSWEG04=1; IOPORT_XMEGA_COMPAT
  group common/components/display/ssd1306
    ../../../../../../common/components/display/ssd1306/: ssd1306.c font.c
  group common/services/gfx_mono
    ../../../../../../common/services/gfx_mono/: gfx_mono_framebuffer.c gfx_mono_text.c gfx_mono_generic.c gfx_mono_ug_2832hsweg04.c sysfont.c
  group common/services/clock/xmega
    ../../../../../../common/services/clock/xmega/: sysclk.c
  group common/services/spi/xmega_usart_spi
    ../../../../../../common/services/spi/xmega_usart_spi/: usart_spi.c
  group common/services/ioport/xmega
    ../../../../../../common/services/ioport/xmega/: ioport_compat.c
  group common/services/sleepmgr/xmega
    ../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group xmega/drivers/usart
    ../../../../usart/: usart.c
  group xmega/drivers/edma
    ../../../: edma.c
  group xmega/drivers/edma/example_1
    ../../: edma_example_1.c
  group xmega/drivers/cpu
    ../../../../cpu/: ccp.s
  group xmega/boards/xmega_e5_xplained
    ../../../../../boards/xmega_e5_xplained/: init.c
