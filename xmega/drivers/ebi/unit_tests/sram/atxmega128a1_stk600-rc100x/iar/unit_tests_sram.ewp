# IAR project unit_tests_sram.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-f.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: _ASSERT_ENABLE_; BOARD=STK600_RC100X; TEST_SUITE_DEFINE_ASSERT_MACRO; IOPORT_XMEGA_COMPAT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../boards/stk600/rc100x; ../../../../../pmic; ../../../../../../utils; ..; ../../..; ../../../../../../../common/services/serial; ../../../../../../../common/services/ioport; ../..; ../../../../../../../common/services/serial/xmega_usart; ../../../../../usart; ../../../../../../../common/services/sleepmgr; ../../../../../../../common/utils; ../../../..; ../../../../../../../common/services/clock; ../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../boards; ../../../../../../../common/services/gpio; ../../../../../../../common/services/hugemem; ../../../../../../../common/boards; ../../../../../../utils/preprocessor; ../../../../../sleep; ../../../../../cpu; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: as above
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _ASSERT_ENABLE_; BOARD=STK600_RC100X; TEST_SUITE_DEFINE_ASSERT_MACRO; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: lnk0t.xcl
  group common/services/sleepmgr/xmega
    ../../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/xmega
    ../../../../../../../common/services/clock/xmega/: sysclk.c
  group common/services/hugemem/avr8
    ../../../../../../../common/services/hugemem/avr8/: avr8_hugemem.c
  group common/services/ioport/xmega
    ../../../../../../../common/services/ioport/xmega/: ioport_compat.c
  group common/utils/unit_test
    ../../../../../../../common/utils/unit_test/: suite.c
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
  group xmega/drivers/ebi
    ../../../../: ebi.c
  group xmega/drivers/ebi/unit_tests
    ../../../: common_tests.c
  group xmega/drivers/ebi/unit_tests/sram
    ../../: unit_tests.c
  group xmega/drivers/usart
    ../../../../../usart/: usart.c
  group xmega/drivers/cpu
    ../../../../../cpu/: ccp.s
  group xmega/boards/stk600/rc100x
    ../../../../../../boards/stk600/rc100x/: init.c
