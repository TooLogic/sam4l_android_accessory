# IAR project adc_example7.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm32e5 ATxmega32E5
  ICCAVR.CCDefines: BOARD=STK600_RC032X; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../common/services/serial; ../../../../../boards/stk600/rc032x; ../../../../../boards; ../../../../pmic; ../../../../sleep; ..; ../../../../cpu; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/boards; ../../../../../utils/preprocessor; ../../../../../utils; ../../../../../../common/services/clock; ../../../../../../common/services/serial/xmega_usart; ../../../../usart; ../../../../dac; ../../../../nvm; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../../../common/services/gpio; ../../..; ../../../../../../common/services/ioport; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=STK600_RC032X; IOPORT_XMEGA_COMPAT
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_RC032X; IOPORT_XMEGA_COMPAT
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/sleepmgr/xmega
    ../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/clock/xmega
    ../../../../../../common/services/clock/xmega/: sysclk.c
  group common/services/ioport/xmega
    ../../../../../../common/services/ioport/xmega/: ioport_compat.c
  group xmega/drivers/adc
    ../../../: adc.c
  group xmega/drivers/adc/xmega_e
    ../../../xmega_e/: adc_e.c
  group xmega/drivers/adc/example7
    ../../: adc_oversampling.c
  group xmega/drivers/dac
    ../../../../dac/: dac.c
  group xmega/drivers/nvm
    ../../../../nvm/: nvm.c nvm_asm.s
  group xmega/drivers/usart
    ../../../../usart/: usart.c
  group xmega/drivers/cpu
    ../../../../cpu/: ccp.s
  group xmega/boards/stk600/rc032x
    ../../../../../boards/stk600/rc032x/: init.c
