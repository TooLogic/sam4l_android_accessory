# IAR project usart_example4.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm32e5 ATxmega32E5
  ICCAVR.CCDefines: BOARD=XMEGA_E5_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ..; ../../../../pmic; ../../../../../../common/services/clock; ../../../../../../common/services/gpio; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../utils; ../../../../../boards/xmega_e5_xplained; ../../../../../utils/preprocessor; ../../..; ../../../../../boards; ../../../../../../common/utils; ../../../../../../common/services/sleepmgr; ../../../../sleep; ../../../../xcl; ../../../../cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=XMEGA_E5_XPLAINED; IOPORT_XMEGA_COMPAT
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_E5_XPLAINED; IOPORT_XMEGA_COMPAT
  group xmega/drivers/usart
    ../../../: usart_xmegae.c usart.c
  group xmega/drivers/usart/example4
    ../../: usart_example4.c
  group xmega/drivers/xcl
    ../../../../xcl/: xcl.c
  group xmega/drivers/cpu
    ../../../../cpu/: ccp.s
  group xmega/boards/xmega_e5_xplained
    ../../../../../boards/xmega_e5_xplained/: init.c
  group common/services/ioport/xmega
    ../../../../../../common/services/ioport/xmega/: ioport_compat.c
  group common/services/sleepmgr/xmega
    ../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/clock/xmega
    ../../../../../../common/services/clock/xmega/: sysclk.c
