# IAR project dma_example2.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128b1 ATxmega128B1
  ICCAVR.CCDefines: BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ..; ../../../../pmic; ../../../../../../common/services/clock; ../../../../../../common/services/gpio; ../../../../../boards/xmega_b1_xplained; ../../../../../../common/boards; ../../../../../utils/preprocessor; ../../../../../utils; ../../..; ../../../../../../common/services/hugemem; ../../../../../../common/services/ioport; ../../../../sleep; ../../../../../boards; ../../../../nvm; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
  group common/services/clock/xmega
    ../../../../../../common/services/clock/xmega/: sysclk.c
  group common/services/hugemem/avr8
    ../../../../../../common/services/hugemem/avr8/: avr8_hugemem.c
  group common/services/sleepmgr/xmega
    ../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/ioport/xmega
    ../../../../../../common/services/ioport/xmega/: ioport_compat.c
  group xmega/boards/xmega_b1_xplained
    ../../../../../boards/xmega_b1_xplained/: init.c
  group xmega/drivers/dma
    ../../../: dma.c
  group xmega/drivers/dma/example2
    ../../: dma_example.c
  group xmega/drivers/nvm
    ../../../../nvm/: nvm.c nvm_asm.s
  group xmega/drivers/cpu
    ../../../../cpu/: ccp.s
