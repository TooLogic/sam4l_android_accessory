# IAR project qdec_example2.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128b1 ATxmega128B1
  ICCAVR.CCDefines: BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../..; ../../../../pmic; ../../../../tc; ../../../../../utils; ../../../../../../common/services/serial; ../../../../../../common/services/ioport; ../../../../../../common/services/serial/xmega_usart; ../../../../usart; ../../../../nvm; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ..; ../../../../../boards/xmega_b1_xplained; ../../../../../../common/services/clock; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../boards; ../../../../../../common/services/gpio; ../..; ../../../../../../common/boards; ../../../../../utils/preprocessor; ../../../../sleep; ../../../../cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/sleepmgr/xmega
    ../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/ioport/xmega
    ../../../../../../common/services/ioport/xmega/: ioport_compat.c
  group common/services/clock/xmega
    ../../../../../../common/services/clock/xmega/: sysclk.c
  group xmega/drivers/qdec
    ../../../: qdec.c
  group xmega/drivers/qdec/example2
    ../../: qdec_example2.c generator_qenc.c
  group xmega/drivers/usart
    ../../../../usart/: usart.c
  group xmega/drivers/nvm
    ../../../../nvm/: nvm.c nvm_asm.s
  group xmega/drivers/tc
    ../../../../tc/: tc.c
  group xmega/drivers/cpu
    ../../../../cpu/: ccp.s
  group xmega/boards/xmega_b1_xplained
    ../../../../../boards/xmega_b1_xplained/: init.c
