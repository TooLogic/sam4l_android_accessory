# IAR project xmega_c3_xplained_demo.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x800
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm384c3 ATxmega384C3
  ICCAVR.CCDefines: _SNS1_SNSK1_SAME_PORT_; QTOUCH_STUDIO_MASKS=1; ACCESS_USB_ENABLED; SD_MMC_ENABLE; BOARD=XMEGA_C3_XPLAINED; ISR_CUSTOM_H="app_cpu_load.h"; SNSK1=F; QT_NUM_CHANNELS=4; _QTOUCH_; GFX_MONO_UG_2832HSWEG04=1; QT_DELAY_CYCLES=1; SNS1=F; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../common/components/memory/sd_mmc; ../../../../../common/services/usb/class/cdc/device; ../../../../drivers/pmic; ../..; ../../../../drivers/tc; ../../../../utils; ../../../../../common/services/gfx_mono; ../../../../../common/services/usb/class/msc; ../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../common/services/calendar; ../../../../../thirdparty/qtouch/generic/include; ../../../../utils/preprocessor; ../../../../../common/utils/stdio/stdio_usb; ../../../../drivers/usart; ../../../../drivers/nvm; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../../common/services/usb/class/composite/device; ../../../../drivers/adc; ../../../../../common/services/usb/class/cdc; ../../../../../common/services/usb/class/msc/device; ../../../../../common/services/clock; ../../../../../common/services/usb/udc; ../../../../../common/services/usb; ../../../../../thirdparty/fatfs/fatfs-port-r0.09/xmega; ../../../../boards; ../../../../../common/services/fifo; ..; ../../../../../common/services/gpio; ../../../../../common/services/delay; ../../../../drivers/usb; ../../../../../common/services/spi; ../../../../../common/boards; ../../../../drivers/rtc; ../../../../boards/xmega_c3_xplained; ../../../../../common/services/ioport; ../../../../../thirdparty/qtouch/generic/avr8/qtouch/common; ../../../../../common/components/display/ssd1306; ../../../../drivers/sleep; ../../../../drivers/cpu; ../../../../../common/services/storage/ctrl_access; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _SNS1_SNSK1_SAME_PORT_; QTOUCH_STUDIO_MASKS=1; ACCESS_USB_ENABLED; SD_MMC_ENABLE; BOARD=XMEGA_C3_XPLAINED; ISR_CUSTOM_H="app_cpu_load.h"; SNSK1=F; QT_NUM_CHANNELS=4; _QTOUCH_; GFX_MONO_UG_2832HSWEG04=1; QT_DELAY_CYCLES=1; SNS1=F; IOPORT_XMEGA_COMPAT
  group thirdparty/qtouch/generic/avr8/qtouch/lib/iar
    ../../../../../thirdparty/qtouch/generic/avr8/qtouch/lib/iar/: libv5xmg1-4qt-k-0rs.r90
  group thirdparty/qtouch/generic/avr8/qtouch/common
    ../../../../../thirdparty/qtouch/generic/avr8/qtouch/common/: qt_asm_xmega.S
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/xmega
    ../../../../../thirdparty/fatfs/fatfs-port-r0.09/xmega/: fattime.c
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c
  group common/services/gfx_mono
    ../../../../../common/services/gfx_mono/: gfx_mono_generic.c sysfont.c gfx_mono_ug_2832hsweg04.c gfx_mono_text.c gfx_mono_framebuffer.c
  group common/services/usb/class/msc/device
    ../../../../../common/services/usb/class/msc/device/: udi_msc.c
  group common/services/usb/class/composite/device
    ../../../../../common/services/usb/class/composite/device/: udi_composite_desc.c
  group common/services/usb/class/cdc/device
    ../../../../../common/services/usb/class/cdc/device/: udi_cdc.c
  group common/services/usb/udc
    ../../../../../common/services/usb/udc/: udc.c
  group common/services/sleepmgr/xmega
    ../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/clock/xmega
    ../../../../../common/services/clock/xmega/: sysclk.c
  group common/services/calendar
    ../../../../../common/services/calendar/: calendar.c
  group common/services/fifo
    ../../../../../common/services/fifo/: fifo.c
  group common/services/ioport/xmega
    ../../../../../common/services/ioport/xmega/: ioport_compat.c
  group common/services/spi/xmega_usart_spi
    ../../../../../common/services/spi/xmega_usart_spi/: usart_spi.c
  group common/components/display/ssd1306
    ../../../../../common/components/display/ssd1306/: font.c ssd1306.c
  group common/components/memory/sd_mmc
    ../../../../../common/components/memory/sd_mmc/: sd_mmc.c sd_mmc_mem.c sd_mmc_spi.c
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_usb
    ../../../../../common/utils/stdio/stdio_usb/: stdio_usb.c
  group xmega/applications/xmega_c3_xplained_demo
    ../../: app_usb.c app_bitmaps.c app_microsd.c app_touch.c app_sampling.c app_cpu_load.c main.c
  group xmega/drivers/adc
    ../../../../drivers/adc/: adc.c
  group xmega/drivers/adc/xmega_bcd
    ../../../../drivers/adc/xmega_bcd/: adc_bcd.c
  group xmega/drivers/nvm
    ../../../../drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/usart
    ../../../../drivers/usart/: usart.c
  group xmega/drivers/rtc
    ../../../../drivers/rtc/: rtc.c
  group xmega/drivers/usb
    ../../../../drivers/usb/: usb_device.c
  group xmega/drivers/tc
    ../../../../drivers/tc/: tc.c
  group xmega/drivers/cpu
    ../../../../drivers/cpu/: ccp.s
  group xmega/boards/xmega_c3_xplained
    ../../../../boards/xmega_c3_xplained/: init.c
