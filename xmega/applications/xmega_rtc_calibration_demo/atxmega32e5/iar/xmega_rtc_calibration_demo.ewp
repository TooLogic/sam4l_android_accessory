# IAR project xmega_rtc_calibration_demo.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm32e5 ATxmega32E5
  ICCAVR.CCDefines: BOARD=DUMMY_BOARD
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../drivers/pmic; ../../../../../common/services/clock; ../../../../drivers/nvm; ../../../../../common/boards; ../../../../drivers/tc45; ../../../../utils; ../../../../utils/preprocessor; ../..; ../../../../boards/dummy; ../../../../boards; ../../../../../common/utils; ../../../../../common/services/sleepmgr; ../../../../drivers/sleep; ../../../../drivers/cpu; ..; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=DUMMY_BOARD
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=DUMMY_BOARD
  group common/services/sleepmgr/xmega
    ../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/clock/xmega
    ../../../../../common/services/clock/xmega/: sysclk.c
  group xmega/applications/xmega_rtc_calibration_demo
    ../../: rtc_calib_procedure.c rtc_calib_main.c
  group xmega/drivers/nvm
    ../../../../drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/tc45
    ../../../../drivers/tc45/: tc45.c
  group xmega/drivers/cpu
    ../../../../drivers/cpu/: ccp.s
