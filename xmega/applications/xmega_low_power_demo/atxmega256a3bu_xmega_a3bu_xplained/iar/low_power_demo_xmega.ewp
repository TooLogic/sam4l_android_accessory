# IAR project low_power_demo_xmega.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../common/services/delay; ../../../../drivers/pmic; ../../../../../common/utils; ../../../../../common/services/clock; ../../../../../common/services/gpio; ../../../../../common/boards; ../../../../utils/preprocessor; ..; ../../../../boards/xmega_a3bu_xplained; ../../../../../common/services/ioport; ../../../../drivers/wdt; ../../../../boards; ../../../../drivers/nvm; ../../../../../common/services/sleepmgr; ../../../../drivers/sleep; ../../../../utils; ../../../../drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  group common/services/sleepmgr/xmega
    ../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/clock/xmega
    ../../../../../common/services/clock/xmega/: sysclk.c
  group common/services/ioport/xmega
    ../../../../../common/services/ioport/xmega/: ioport_compat.c
  group xmega/boards/xmega_a3bu_xplained
    ../../../../boards/xmega_a3bu_xplained/: init.c
  group xmega/applications/xmega_low_power_demo
    ../../: low_power_demo.c
  group xmega/drivers/wdt
    ../../../../drivers/wdt/: wdt.c
  group xmega/drivers/nvm
    ../../../../drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/cpu
    ../../../../drivers/cpu/: ccp.s
