# IAR project xmega_b1_xplained_voltage_meter.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128b1 ATxmega128B1
  ICCAVR.CCDefines: BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../components/display/c42048a/c42048a_full_matrix0; ../../../../drivers/pmic; ../../../../../common/services/clock; ../../../../drivers/adc; ..; ../../../../boards/xmega_b1_xplained; ../../../../../common/boards; ../../../../utils/preprocessor; ../../../../drivers/tc; ../../../../utils; ../../../../../common/services/ioport; ../../../../drivers/sleep; ../../../../drivers/cpu; ../../../../boards; ../../../../drivers/lcd; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../drivers/nvm; ../..; ../../../../../common/services/gpio; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
  group common/services/sleepmgr/xmega
    ../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/clock/xmega
    ../../../../../common/services/clock/xmega/: sysclk.c
  group common/services/ioport/xmega
    ../../../../../common/services/ioport/xmega/: ioport_compat.c
  group xmega/drivers/adc
    ../../../../drivers/adc/: adc.c
  group xmega/drivers/adc/xmega_bcd
    ../../../../drivers/adc/xmega_bcd/: adc_bcd.c
  group xmega/drivers/tc
    ../../../../drivers/tc/: tc.c
  group xmega/drivers/lcd
    ../../../../drivers/lcd/: lcd.c
  group xmega/drivers/nvm
    ../../../../drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/cpu
    ../../../../drivers/cpu/: ccp.s
  group xmega/applications/xmega_b1_xplained_voltage_meter
    ../../: ui.c main.c
  group xmega/boards/xmega_b1_xplained
    ../../../../boards/xmega_b1_xplained/: init.c
  group xmega/components/display/c42048a/c42048a_full_matrix0
    ../../../../components/display/c42048a/c42048a_full_matrix0/: c42048a.c
