# IAR project xmega_e5_xplained_demo.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x800
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm32e5 ATxmega32E5
  ICCAVR.CCDefines: ISR_CUSTOM_H="app_cpu_load.h"; BOARD=XMEGA_E5_XPLAINED; GFX_MONO_UG_2832HSWEG04=1; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../drivers/qdec; ../../../../drivers/pmic; ../../../../utils; ../../../../../common/services/gfx_mono; ..; ../../../../../common/services/serial; ../../../../../common/services/ioport; ../../../../../common/services/serial/xmega_usart; ../../../../drivers/usart; ../../../../drivers/nvm; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../..; ../../../../drivers/adc; ../../../../../common/services/clock; ../../../../../common/utils/stdio/stdio_serial; ../../../../boards; ../../../../../common/services/fifo; ../../../../../common/services/gpio; ../../../../../common/services/delay; ../../../../boards/xmega_e5_xplained; ../../../../../common/services/spi; ../../../../../common/boards; ../../../../drivers/tc45; ../../../../drivers/rtc; ../../../../utils/preprocessor; ../../../../../common/components/display/ssd1306; ../../../../drivers/sleep; ../../../../drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; ISR_CUSTOM_H="app_cpu_load.h"; BOARD=XMEGA_E5_XPLAINED; GFX_MONO_UG_2832HSWEG04=1; IOPORT_XMEGA_COMPAT
  group common/services/gfx_mono
    ../../../../../common/services/gfx_mono/: gfx_mono_generic.c sysfont.c gfx_mono_ug_2832hsweg04.c gfx_mono_text.c gfx_mono_framebuffer.c
  group common/services/sleepmgr/xmega
    ../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/clock/xmega
    ../../../../../common/services/clock/xmega/: sysclk.c
  group common/services/spi/xmega_usart_spi
    ../../../../../common/services/spi/xmega_usart_spi/: usart_spi.c
  group common/services/fifo
    ../../../../../common/services/fifo/: fifo.c
  group common/services/ioport/xmega
    ../../../../../common/services/ioport/xmega/: ioport_compat.c
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c
  group common/components/display/ssd1306
    ../../../../../common/components/display/ssd1306/: font.c ssd1306.c
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group xmega/drivers/adc
    ../../../../drivers/adc/: adc.c
  group xmega/drivers/adc/xmega_e
    ../../../../drivers/adc/xmega_e/: adc_e.c
  group xmega/drivers/qdec
    ../../../../drivers/qdec/: qdec.c
  group xmega/drivers/nvm
    ../../../../drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/usart
    ../../../../drivers/usart/: usart.c
  group xmega/drivers/rtc
    ../../../../drivers/rtc/: rtc.c
  group xmega/drivers/tc45
    ../../../../drivers/tc45/: tc45.c
  group xmega/drivers/cpu
    ../../../../drivers/cpu/: ccp.s
  group xmega/applications/xmega_e5_xplained_demo
    ../../: app_bitmaps.c app_cpu_load.c main.c app_sampling.c
  group xmega/boards/xmega_e5_xplained
    ../../../../boards/xmega_e5_xplained/: init.c
