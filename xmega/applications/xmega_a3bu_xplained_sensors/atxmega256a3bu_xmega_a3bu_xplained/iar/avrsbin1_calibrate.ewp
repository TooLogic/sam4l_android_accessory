# IAR project avrsbin1_calibrate.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; GFX_MONO_C12832_A1Z=1; BOARD=XMEGA_A3BU_XPLAINED; EXT_BOARD=SENSORS_XPLAINED_INERTIAL_1; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../drivers/pmic; ../../../../../common/services/sensors; ../../../../utils; ../../../../../common/services/gfx_mono; ../..; ../../conf; ../../../../../common/services/twi; ../../../../../common/services/ioport; ../../../../drivers/usart; ../../../../drivers/nvm; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../../common/components/display/st7565r; ../../../../../common/services/clock; ../../../../boards/xmega_a3bu_xplained; ../../../../boards; ../../../../../common/services/gpio; ../../../../../common/services/delay; ../../../../drivers/twi; ../../../../../common/services/spi; ../../../../../common/boards; ../../../../utils/preprocessor; ../../../../drivers/sleep; ../../../../../common/services/sensors/module_config; ../../../../drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; GFX_MONO_C12832_A1Z=1; BOARD=XMEGA_A3BU_XPLAINED; EXT_BOARD=SENSORS_XPLAINED_INERTIAL_1; IOPORT_XMEGA_COMPAT
  group xmega/boards/xmega_a3bu_xplained
    ../../../../boards/xmega_a3bu_xplained/: init.c
  group xmega/drivers/twi
    ../../../../drivers/twi/: twim.c twis.c
  group xmega/drivers/nvm
    ../../../../drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/usart
    ../../../../drivers/usart/: usart.c
  group xmega/drivers/cpu
    ../../../../drivers/cpu/: ccp.s
  group xmega/applications/xmega_a3bu_xplained_sensors
    ../../: compass_calibrate.c
  group common/services/gfx_mono
    ../../../../../common/services/gfx_mono/: gfx_mono_generic.c sysfont.c gfx_mono_text.c gfx_mono_framebuffer.c gfx_mono_c12832_a1z.c
  group common/services/sensors
    ../../../../../common/services/sensors/: sensor_bus.c sensor.c sensor_platform.c sensor_nvram.c
  group common/services/sensors/drivers/honeywell
    ../../../../../common/services/sensors/drivers/honeywell/: hmc5883l.c
  group common/services/sensors/drivers/bosch
    ../../../../../common/services/sensors/drivers/bosch/: bmp.c bma180.c bma_axis.inc.c bma222.c bma220.c bma150.c bma020.c bma250.c
  group common/services/sensors/drivers/kionix
    ../../../../../common/services/sensors/drivers/kionix/: kxtf9.c
  group common/services/sensors/drivers/invensense
    ../../../../../common/services/sensors/drivers/invensense/: imu3000.c itg3200.c
  group common/services/sensors/drivers/osram
    ../../../../../common/services/sensors/drivers/osram/: sfh7770.c sfh5712.c
  group common/services/sensors/drivers/akm
    ../../../../../common/services/sensors/drivers/akm/: ak8975.c
  group common/services/sensors/physics
    ../../../../../common/services/sensors/physics/: physics.c
  group common/services/sleepmgr/xmega
    ../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/clock/xmega
    ../../../../../common/services/clock/xmega/: sysclk.c
  group common/services/spi/xmega_usart_spi
    ../../../../../common/services/spi/xmega_usart_spi/: usart_spi.c
  group common/services/ioport/xmega
    ../../../../../common/services/ioport/xmega/: ioport_compat.c
  group common/boards/sensors_xplained
    ../../../../../common/boards/sensors_xplained/: sensors_xplained.c
  group common/components/display/st7565r
    ../../../../../common/components/display/st7565r/: st7565r.c
