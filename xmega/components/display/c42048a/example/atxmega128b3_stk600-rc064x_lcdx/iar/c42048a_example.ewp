# IAR project c42048a_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128b3 ATxmega128B3
  ICCAVR.CCDefines: BOARD=STK600_RC064X_LCDX; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../drivers/pmic; ../../../../../../../common/services/clock; ../../../../../../../common/services/gpio; ../../../../../../drivers/nvm; ../../../../../../../common/boards; ../../../../../../../common/services/ioport; ../../../../../../drivers/tc; ../../../../../../utils; ../../../../../../boards/stk600/rc064x_lcdx; ../../../../../../utils/preprocessor; ..; ../../../c42048a_partial_matrix0; ../../../../../../../common/utils; ../../../../../../boards; ../../../../../../drivers/lcd; ../../../../../../../common/services/sleepmgr; ../../../../../../drivers/sleep; ../../../../../../drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=STK600_RC064X_LCDX; IOPORT_XMEGA_COMPAT
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_RC064X_LCDX; IOPORT_XMEGA_COMPAT
  group common/services/sleepmgr/xmega
    ../../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/ioport/xmega
    ../../../../../../../common/services/ioport/xmega/: ioport_compat.c
  group common/services/clock/xmega
    ../../../../../../../common/services/clock/xmega/: sysclk.c
  group xmega/boards/stk600/rc064x_lcdx
    ../../../../../../boards/stk600/rc064x_lcdx/: init.c
  group xmega/components/display/c42048a/example
    ../../: lcd_c42048a_example.c
  group xmega/components/display/c42048a/c42048a_partial_matrix0
    ../../../c42048a_partial_matrix0/: c42048a.c
  group xmega/drivers/nvm
    ../../../../../../drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/tc
    ../../../../../../drivers/tc/: tc.c
  group xmega/drivers/lcd
    ../../../../../../drivers/lcd/: lcd.c
  group xmega/drivers/cpu
    ../../../../../../drivers/cpu/: ccp.s
