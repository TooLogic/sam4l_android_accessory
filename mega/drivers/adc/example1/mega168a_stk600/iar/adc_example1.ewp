# IAR project adc_example1.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=STK600_MEGA
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: ..; ../../../../../../common/utils; ../../../../../../common/boards; ../../..; ../../../../../utils; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: BOARD=STK600_MEGA
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm2560.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_MEGA
  group mega/boards/stk600/rcx_x
    ../../../../../boards/stk600/rcx_x/: init.c
  group mega/drivers/adc/example1
    ../../: adc_example1.c
