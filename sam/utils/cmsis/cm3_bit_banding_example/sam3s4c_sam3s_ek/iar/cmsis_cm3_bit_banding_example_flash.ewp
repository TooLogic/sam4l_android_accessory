# IAR project cmsis_cm3_bit_banding_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3S4C__; BOARD=SAM3S_EK
  ICCARM.CCIncludePath2: ../../../sam3s/include; ../../../..; ../../../../../boards/sam3s_ek; ../../../../../boards; ../../../../header_files; ../../../../../../common/boards; ../../../../preprocessor; ../../../../../drivers/pio; ..; ../../../../../../common/utils; ../../../../../../common/services/gpio; ../../../sam3s/source/templates; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3S4C__; BOARD=SAM3S_EK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cmsis_cm3_bit_banding_example_flash.bin
  ILINK.IlinkOutputFile: cmsis_cm3_bit_banding_example_flash.out
  ILINK.IlinkIcfFile: ../../../../linker_scripts/sam3s/sam3s4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam3s/source/templates
    ../../../sam3s/source/templates/: system_sam3s.c exceptions.c
  group sam/utils/cmsis/sam3s/source/templates/iar
    ../../../sam3s/source/templates/iar/: startup_sam3s.c
  group sam/utils/cmsis/cm3_bit_banding_example
    ../../: main.c
  group sam/boards/sam3s_ek
    ../../../../../boards/sam3s_ek/: led.c init.c
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio.c pio_handler.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
