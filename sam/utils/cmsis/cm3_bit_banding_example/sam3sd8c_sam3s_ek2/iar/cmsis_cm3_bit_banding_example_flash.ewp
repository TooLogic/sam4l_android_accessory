# IAR project cmsis_cm3_bit_banding_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3SD8 Atmel SAM3SD8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3SD8C__; BOARD=SAM3S_EK2
  ICCARM.CCIncludePath2: ../../../..; ../../../sam3s8/source/templates; ../../../../../boards; ../../../../header_files; ../../../../../../common/boards; ../../../../preprocessor; ../../../../../drivers/pio; ..; ../../../sam3s8/include; ../../../../../../common/utils; ../../../../../boards/sam3s_ek2; ../../../../../../common/services/gpio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3SD8C__; BOARD=SAM3S_EK2
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cmsis_cm3_bit_banding_example_flash.bin
  ILINK.IlinkOutputFile: cmsis_cm3_bit_banding_example_flash.out
  ILINK.IlinkIcfFile: ../../../../linker_scripts/sam3s/sam3sd8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c
  group sam/utils/cmsis/sam3s8/source/templates
    ../../../sam3s8/source/templates/: exceptions.c system_sam3sd8.c
  group sam/utils/cmsis/sam3s8/source/templates/iar
    ../../../sam3s8/source/templates/iar/: startup_sam3sd8.c
  group sam/utils/cmsis/cm3_bit_banding_example
    ../../: main.c
  group sam/boards/sam3s_ek2
    ../../../../../boards/sam3s_ek2/: init.c led.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
