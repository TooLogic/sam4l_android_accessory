# IAR project cmsis_cm3_nvic_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3N4 Atmel SAM3N4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3N_EK; __SAM3N4C__
  ICCARM.CCIncludePath2: ../../../../header_files; ../../../../../drivers/uart; ../..; ../../../..; ../../../sam3n/source/templates; ../../../../../boards; ../../../../../drivers/usart; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/boards; ../../../../preprocessor; ..; ../../../../../../common/services/clock; ../../../sam3n/include; ../../../../../drivers/pmc; ../../../../../drivers/pio; ../../../../../boards/sam3n_ek; ../../../../../../common/utils; ../../../../../../common/services/gpio; ../../../../../../common/services/serial; ../../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM3N_EK; __SAM3N4C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cmsis_cm3_nvic_example_flash.bin
  ILINK.IlinkOutputFile: cmsis_cm3_nvic_example_flash.out
  ILINK.IlinkIcfFile: ../../../../linker_scripts/sam3n/sam3n4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam3n/source/templates
    ../../../sam3n/source/templates/: exceptions.c system_sam3n.c
  group sam/utils/cmsis/sam3n/source/templates/iar
    ../../../sam3n/source/templates/iar/: startup_sam3n.c
  group sam/utils/cmsis/cm3_nvic_example
    ../../: main.c
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c
  group sam/drivers/usart
    ../../../../../drivers/usart/: usart.c
  group sam/boards/sam3n_ek
    ../../../../../boards/sam3n_ek/: init.c led.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam3n
    ../../../../../../common/services/clock/sam3n/: sysclk.c
