# IAR project cmsis_cm3_nvic_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3SD8 Atmel SAM3SD8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3SD8C__; BOARD=SAM3S_EK2
  ICCARM.CCIncludePath2: ../../../../../../common/services/clock; ../../../../header_files; ../../../../../drivers/uart; ../..; ../../../..; ..; ../../../../../boards; ../../../../../drivers/usart; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/boards; ../../../../preprocessor; ../../../sam3s8/source/templates; ../../../../../drivers/pmc; ../../../../../drivers/pio; ../../../sam3s8/include; ../../../../../../common/utils; ../../../../../boards/sam3s_ek2; ../../../../../../common/services/gpio; ../../../../../../common/services/serial; ../../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3SD8C__; BOARD=SAM3S_EK2
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cmsis_cm3_nvic_example_flash.bin
  ILINK.IlinkOutputFile: cmsis_cm3_nvic_example_flash.out
  ILINK.IlinkIcfFile: ../../../../linker_scripts/sam3s/sam3sd8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: sleep.c pmc.c
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c
  group sam/drivers/usart
    ../../../../../drivers/usart/: usart.c
  group sam/utils/cmsis/sam3s8/source/templates
    ../../../sam3s8/source/templates/: exceptions.c system_sam3sd8.c
  group sam/utils/cmsis/sam3s8/source/templates/iar
    ../../../sam3s8/source/templates/iar/: startup_sam3sd8.c
  group sam/utils/cmsis/cm3_nvic_example
    ../../: main.c
  group sam/boards/sam3s_ek2
    ../../../../../boards/sam3s_ek2/: led.c init.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam3s
    ../../../../../../common/services/clock/sam3s/: sysclk.c
