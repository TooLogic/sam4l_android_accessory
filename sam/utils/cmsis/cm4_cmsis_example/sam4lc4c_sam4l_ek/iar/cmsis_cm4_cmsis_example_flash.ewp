# IAR project cmsis_cm4_cmsis_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../sam4l/source/templates; ../../../../../boards/sam4l_ek; ../../../..; ../../../../../../common/services/clock; ../../../../../boards; ../../../../header_files; ../../../../../drivers/flashcalw; ../../../../preprocessor; ../../../../../../common/boards; ../../../sam4l/include; ../../../../../../common/services/ioport; ../../../../../drivers/bpm; ../../../../../../common/utils; ..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cmsis_cm4_cmsis_example_flash.bin
  ILINK.IlinkOutputFile: cmsis_cm4_cmsis_example_flash.out
  ILINK.IlinkIcfFile: ../../../../linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam4l/source/templates
    ../../../sam4l/source/templates/: exceptions.c system_sam4l.c
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/cm4_cmsis_example
    ../../: main.c
  group sam/drivers/flashcalw
    ../../../../../drivers/flashcalw/: flashcalw.c
  group sam/drivers/bpm
    ../../../../../drivers/bpm/: bpm.c
  group sam/boards/sam4l_ek
    ../../../../../boards/sam4l_ek/: init.c
  group common/services/clock/sam4l
    ../../../../../../common/services/clock/sam4l/: osc.c sysclk.c dfll.c pll.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
