# IAR project cmsis_cm4_nvic_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4S_EK; ARM_MATH_CM4=true; __SAM4S16C__
  ICCARM.CCIncludePath2: ../../../sam4s/source/templates; ../../../../header_files; ../../../../../drivers/uart; ../../../..; ../../../../../../common/services/clock; ../..; ../../../../../drivers/usart; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/boards; ../../../../preprocessor; ../../../../../drivers/pmc; ../../../../../drivers/pio; ../../../../../boards; ../../../../../boards/sam4s_ek; ../../../../../../common/utils; ../../../sam4s/include; ..; ../../../../../../common/services/gpio; ../../../../../../common/services/serial; ../../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4S_EK; ARM_MATH_CM4=true; __SAM4S16C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cmsis_cm4_nvic_example_flash.bin
  ILINK.IlinkOutputFile: cmsis_cm4_nvic_example_flash.out
  ILINK.IlinkIcfFile: ../../../../linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c
  group sam/drivers/usart
    ../../../../../drivers/usart/: usart.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../sam4s/source/templates/: exceptions.c system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/cm4_nvic_example
    ../../: main.c
  group sam/boards/sam4s_ek
    ../../../../../boards/sam4s_ek/: led.c init.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam4s
    ../../../../../../common/services/clock/sam4s/: sysclk.c
