# IAR project sam_toolkit_demo_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4SD32C Atmel SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM4=true; DEF_TOUCH_QDEBUG_ENABLE_QM=0; _SNS1_SNSK1_SAME_PORT_; BOARD=SAM4S_EK2; SNSK1=C; SNSK2=A; _SNS2_SNSK2_SAME_PORT_; ACCESS_USB_ENABLED; UDD_ENABLE; DEF_TOUCH_QDEBUG_ENABLE_QTB=0; SNS1=C; QT_DELAY_CYCLES=5; CONF_GFX_ILI9325_FTM280C34D=1; DEF_TOUCH_QDEBUG_ENABLE_AT=0; DEF_TOUCH_QDEBUG_ENABLE_QTA=0; _QTOUCH_; __SAM4SD32C__; QT_NUM_CHANNELS=32; SNS2=A; _DEBUG_INTERFACE_; QTOUCH_SLIDER_REVERSED
  ICCARM.CCIncludePath2: ../../../../drivers/adc; ../../../../../common/services/serial/sam_uart; ../../../../../common/services/spi/sam_spi; ../../../../utils/preprocessor; ../../../../../thirdparty/qtouch/qdebug; ../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam; ../../../../utils/cmsis/sam4s/include; ../../../../drivers/pmc; ../../../../drivers/efc; ../../../../drivers/ebi/smc; ../../../../../common/services/gfx; ../../../../../thirdparty/qtouch/generic/include; ../../../../../common/utils/membag; ../../../../../common/services/serial; ../../../../drivers/rtc; ../../../../services/flash_efc; ../../../../drivers/spi; ../../../../drivers/supc; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../drivers/wdt; ../..; ../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/iar/sam; ../../../../../common/services/usb/class/msc/device; ../../../../components/resistive_touch/ads7843; ../../../../../common/services/clock; ../../../../drivers/matrix; ../../../../components/display/aat31xx; ../../../../../common/utils/stdio/stdio_serial; ../../../../../common/components/memory/nand_flash/nand_flash_ebi; ../../../../../common/components/memory/nand_flash/nand_flash_ebi/ftl_lib; ../../../../../common/services/usb/udc; ../../../../../common/services/usb; ../../../../boards/sam4s_ek2; ../../../../drivers/udp; ../../../../drivers/uart; ../../../../../common/services/gpio; ../../../../../common/services/storage/ecc_hamming; ../../../../drivers/pdc; ../../../../utils/cmsis/sam4s/source/templates; ../../../../../common/services/wtk; ../../../../../common/services/delay; ../../../../../thirdparty/qtouch/generic/sam/qtouch/common; ../../../../../thirdparty/freertos/freertos-7.0.0/source/include; ../../../../utils; ../../../../drivers/tc; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../../common/boards; ../../../../services/resistive_touch; ../../../../components/display/ili9325; ../../../../../common/services/usb/class/msc; ../../../../../common/services/ioport; ../../../../drivers/pio; ../../../../boards; ..; ../../../../../common/services/spi; ../../../../../common/services/storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sam_toolkit_demo_flash.bin
  ILINK.IlinkOutputFile: sam_toolkit_demo_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam4s/sam4sd32/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x8000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/qtouch/generic/sam/qtouch/lib/iar
    ../../../../../thirdparty/qtouch/generic/sam/qtouch/lib/iar/: libsam4s-32qt-k-8rs-iar.a
  group thirdparty/qtouch/generic/sam/qtouch/common
    ../../../../../thirdparty/qtouch/generic/sam/qtouch/common/: BitBangSPI_Master.c
  group thirdparty/qtouch/qdebug
    ../../../../../thirdparty/qtouch/qdebug/: QDebug.c QDebugTransport.c
  group thirdparty/freertos/freertos-7.0.0/source
    ../../../../../thirdparty/freertos/freertos-7.0.0/source/: list.c tasks.c croutine.c queue.c timers.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/memmang
    ../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/memmang/: heap_3.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/iar/sam
    ../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/iar/sam/: port.c portasm.s
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam/: fattime_rtc.c
  group common/components/memory/nand_flash/nand_flash_ebi
    ../../../../../common/components/memory/nand_flash/nand_flash_ebi/: nand_flash_ecc_sw.c nand_flash_spare_scheme.c nand_flash_model.c nand_flash_raw_smc.c
  group common/components/memory/nand_flash/nand_flash_ebi/ftl_lib
    ../../../../../common/components/memory/nand_flash/nand_flash_ebi/ftl_lib/: nand_flash_mem.c
  group common/components/memory/nand_flash/nand_flash_ebi/ftl_lib/iar
    ../../../../../common/components/memory/nand_flash/nand_flash_ebi/ftl_lib/iar/: lib_nand_flash_cortexm4.a
  group common/services/delay/sam
    ../../../../../common/services/delay/sam/: cycle_counter.c
  group common/services/gfx
    ../../../../../common/services/gfx/: gfx_text.c gfx_ili9325_ftm280c34d.c gfx_generic.c sysfont.c
  group common/services/wtk
    ../../../../../common/services/wtk/: wtk_progress_bar.c wtk_radio_button.c wtk_check_box.c wtk_label.c wtk_icon.c wtk_button.c wtk_basic_frame.c wtk_slider.c win.c wtk_plot.c wtk.c wtk_frame.c
  group common/services/usb/class/msc/device
    ../../../../../common/services/usb/class/msc/device/: udi_msc_desc.c udi_msc.c
  group common/services/usb/udc
    ../../../../../common/services/usb/udc/: udc.c
  group common/services/spi/sam_spi
    ../../../../../common/services/spi/sam_spi/: spi_master.c
  group common/services/clock/sam4s
    ../../../../../common/services/clock/sam4s/: sysclk.c
  group common/services/storage/ecc_hamming
    ../../../../../common/services/storage/ecc_hamming/: ecc-sw.c
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c
  group common/services/sleepmgr/sam
    ../../../../../common/services/sleepmgr/sam/: sleepmgr.c
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/membag
    ../../../../../common/utils/membag/: membag.c
  group sam/applications/sam_toolkit_demo
    ../../: widget_scr_settings_date.c widget_scr_settings_backlight.c widget_scr_qtouch.c widget_scr_main.c widget_scr_lpm_wait.c widget_scr_settings.c widget_scr_lpm.c widget_scr_lpm_sleep.c rtouch_calibrate.c widget_scr_audio.c widget_scr_lpm_backup.c demo_qtouch.c widget_scr_settings_time.c demo_draw_bmpfile.c demo_parameters.c widget_scr_fft.c demo.c widget_scr_info.c
  group sam/applications/sam_toolkit_demo/sam4sd32c_sam4s_ek2
    ../: demo_board.c
  group sam/components/resistive_touch/ads7843
    ../../../../components/resistive_touch/ads7843/: ads7843.c
  group sam/components/display/aat31xx
    ../../../../components/display/aat31xx/: aat31xx.c
  group sam/components/display/ili9325
    ../../../../components/display/ili9325/: ili9325.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../utils/cmsis/sam4s/source/templates/: exceptions.c system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/drivers/pio
    ../../../../drivers/pio/: pio.c pio_handler.c
  group sam/drivers/pdc
    ../../../../drivers/pdc/: pdc.c
  group sam/drivers/supc
    ../../../../drivers/supc/: supc.c
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c
  group sam/drivers/wdt
    ../../../../drivers/wdt/: wdt.c
  group sam/drivers/udp
    ../../../../drivers/udp/: udp_device.c
  group sam/drivers/adc
    ../../../../drivers/adc/: adc_sam3u.c adc.c
  group sam/drivers/efc
    ../../../../drivers/efc/: efc.c
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c
  group sam/drivers/matrix
    ../../../../drivers/matrix/: matrix.c
  group sam/drivers/tc
    ../../../../drivers/tc/: tc.c
  group sam/drivers/ebi/smc
    ../../../../drivers/ebi/smc/: smc.c
  group sam/drivers/rtc
    ../../../../drivers/rtc/: rtc.c
  group sam/drivers/spi
    ../../../../drivers/spi/: spi.c
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c
  group sam/services/resistive_touch
    ../../../../services/resistive_touch/: rtouch.c
  group sam/services/flash_efc
    ../../../../services/flash_efc/: flash_efc.c
  group sam/boards/sam4s_ek2
    ../../../../boards/sam4s_ek2/: led.c
