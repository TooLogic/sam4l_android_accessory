# IAR project getting-started_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3X8E__; BOARD=ARDUINO_DUE_X
  ICCARM.CCIncludePath2: ../../../../utils/header_files; ../..; ../../../../boards; ../../../../utils; ../../../../../common/services/clock; ..; ../../../../drivers/usart; ../../../../../common/utils/stdio/stdio_serial; ../../../../../common/boards; ../../../../utils/preprocessor; ../../../../utils/cmsis/sam3x/include; ../../../../drivers/pmc; ../../../../drivers/pio; ../../../../../common/utils; ../../../../drivers/tc; ../../../../drivers/uart; ../../../../boards/arduino_due_x; ../../../../../common/services/gpio; ../../../../../common/services/serial; ../../../../utils/cmsis/sam3x/source/templates; ../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3X8E__; BOARD=ARDUINO_DUE_X
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: getting-started_flash.bin
  ILINK.IlinkOutputFile: getting-started_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/clock/sam3x
    ../../../../../common/services/clock/sam3x/: sysclk.c
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group sam/drivers/tc
    ../../../../drivers/tc/: tc.c
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../utils/cmsis/sam3x/source/templates/: exceptions.c system_sam3x.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/boards/arduino_due_x
    ../../../../boards/arduino_due_x/: init.c
  group sam/applications/getting-started
    ../../: main.c
