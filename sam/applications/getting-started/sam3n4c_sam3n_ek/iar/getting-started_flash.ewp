# IAR project getting-started_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3N4 Atmel SAM3N4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3N_EK; __SAM3N4C__
  ICCARM.CCIncludePath2: ../../../../utils/header_files; ../../../../drivers/uart; ../../../../boards; ../../../../utils; ../../../../utils/cmsis/sam3n/source/templates; ../../../../drivers/tc; ../../../../drivers/usart; ../../../../../common/utils/stdio/stdio_serial; ../../../../../common/boards; ../../../../utils/preprocessor; ../../../../../common/services/clock; ../../../../utils/cmsis/sam3n/include; ../../../../drivers/pmc; ../../../../drivers/pio; ../../../../../common/utils; ..; ../../../../boards/sam3n_ek; ../..; ../../../../../common/services/gpio; ../../../../../common/services/serial; ../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM3N_EK; __SAM3N4C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: getting-started_flash.bin
  ILINK.IlinkOutputFile: getting-started_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam3n/sam3n4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c
  group sam/drivers/tc
    ../../../../drivers/tc/: tc.c
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c
  group sam/utils/cmsis/sam3n/source/templates
    ../../../../utils/cmsis/sam3n/source/templates/: exceptions.c system_sam3n.c
  group sam/utils/cmsis/sam3n/source/templates/iar
    ../../../../utils/cmsis/sam3n/source/templates/iar/: startup_sam3n.c
  group sam/boards/sam3n_ek
    ../../../../boards/sam3n_ek/: init.c led.c
  group sam/applications/getting-started
    ../../: main.c
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/clock/sam3n
    ../../../../../common/services/clock/sam3n/: sysclk.c
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c
