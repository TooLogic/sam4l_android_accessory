# IAR project getting-started_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3S4C__; BOARD=SAM3S_EK
  ICCARM.CCIncludePath2: ..; ../../../../drivers/uart; ../../../../boards; ../../../../utils; ../../../../boards/sam3s_ek; ../../../../../common/services/clock; ../../../../drivers/tc; ../../../../drivers/usart; ../../../../utils/cmsis/sam3s/include; ../../../../../common/boards; ../../../../utils/preprocessor; ../../../../utils/cmsis/sam3s/source/templates; ../../../../drivers/pmc; ../../../../drivers/pio; ../../../../../common/utils; ../..; ../../../../../common/utils/stdio/stdio_serial; ../../../../utils/header_files; ../../../../../common/services/gpio; ../../../../../common/services/serial; ../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3S4C__; BOARD=SAM3S_EK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: getting-started_flash.bin
  ILINK.IlinkOutputFile: getting-started_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam3s/sam3s4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/boards/sam3s_ek
    ../../../../boards/sam3s_ek/: led.c init.c
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c
  group sam/drivers/tc
    ../../../../drivers/tc/: tc.c
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c
  group sam/utils/cmsis/sam3s/source/templates
    ../../../../utils/cmsis/sam3s/source/templates/: system_sam3s.c exceptions.c
  group sam/utils/cmsis/sam3s/source/templates/iar
    ../../../../utils/cmsis/sam3s/source/templates/iar/: startup_sam3s.c
  group sam/applications/getting-started
    ../../: main.c
  group common/services/clock/sam3s
    ../../../../../common/services/clock/sam3s/: sysclk.c
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
