# IAR project getting-started_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../common/services/serial/sam_uart; ../../../../../common/boards; ../../../../utils/preprocessor; ../../../../utils/cmsis/sam4l/include; ../../../../utils/cmsis/sam4l/source/templates; ../../../../../common/services/serial; ../../../../drivers/eic; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../boards/sam4l_ek; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/utils/stdio/stdio_serial; ..; ../../../../../common/services/delay; ../..; ../../../../utils; ../../../../drivers/tc; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../drivers/flashcalw; ../../../../../common/services/ioport; ../../../../drivers/bpm; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: getting-started_flash.bin
  ILINK.IlinkOutputFile: getting-started_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/clock/sam4l
    ../../../../../common/services/clock/sam4l/: osc.c dfll.c pll.c sysclk.c
  group common/services/sleepmgr/sam4l
    ../../../../../common/services/sleepmgr/sam4l/: sleepmgr.c
  group common/services/delay/sam
    ../../../../../common/services/delay/sam/: cycle_counter.c
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group sam/drivers/flashcalw
    ../../../../drivers/flashcalw/: flashcalw.c
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c
  group sam/drivers/tc
    ../../../../drivers/tc/: tc.c
  group sam/drivers/eic
    ../../../../drivers/eic/: eic.c
  group sam/drivers/bpm
    ../../../../drivers/bpm/: bpm.c
  group sam/applications/getting-started
    ../../: main_sam4l.c
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../utils/cmsis/sam4l/source/templates/: system_sam4l.c exceptions.c
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/boards/sam4l_ek
    ../../../../boards/sam4l_ek/: init.c board_monitor.c
