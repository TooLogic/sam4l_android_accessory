# IAR project getting-started_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3SD8 Atmel SAM3SD8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3SD8C__; BOARD=SAM3S_EK2
  ICCARM.CCIncludePath2: ..; ../../../../drivers/uart; ../../../../boards; ../../../../utils; ../../../../utils/cmsis/sam3s8/source/templates; ../../../../drivers/tc; ../../../../drivers/usart; ../../../../../common/utils/stdio/stdio_serial; ../../../../../common/boards; ../../../../utils/preprocessor; ../../../../../common/services/clock; ../../../../drivers/pmc; ../../../../drivers/pio; ../../../../utils/cmsis/sam3s8/include; ../../../../../common/utils; ../..; ../../../../boards/sam3s_ek2; ../../../../utils/header_files; ../../../../../common/services/gpio; ../../../../../common/services/serial; ../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3SD8C__; BOARD=SAM3S_EK2
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: getting-started_flash.bin
  ILINK.IlinkOutputFile: getting-started_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam3s/sam3sd8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam3s8/source/templates
    ../../../../utils/cmsis/sam3s8/source/templates/: system_sam3sd8.c exceptions.c
  group sam/utils/cmsis/sam3s8/source/templates/iar
    ../../../../utils/cmsis/sam3s8/source/templates/iar/: startup_sam3sd8.c
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c
  group sam/drivers/tc
    ../../../../drivers/tc/: tc.c
  group sam/boards/sam3s_ek2
    ../../../../boards/sam3s_ek2/: led.c init.c
  group sam/applications/getting-started
    ../../: main.c
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam3s
    ../../../../../common/services/clock/sam3s/: sysclk.c
