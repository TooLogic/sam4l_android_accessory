# IAR project sam4s_xplained_qtouch_demo_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _SNS1_SNSK1_SAME_PORT_; SNSK1=A; ARM_MATH_CM4=true; __SAM4S16C__; SNS1=A; QT_DELAY_CYCLES=3; _QTOUCH_; QT_NUM_CHANNELS=32; _DEBUG_INTERFACE_; BOARD=SAM4S_XPLAINED
  ICCARM.CCIncludePath2: ..; ../../../../../common/services/serial/sam_uart; ../../../../utils/preprocessor; ../../../../drivers/pmc; ../../../../utils/cmsis/sam4s/include; ../../../../../thirdparty/qtouch/generic/include; ../../../../../common/services/serial; ../../../../../thirdparty/qtouch/qdebug; ../../../../../common/utils; ../../../../drivers/wdt; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../../thirdparty/qtouch/generic/sam/qtouch/common; ../../../../../common/services/gpio; ../../../../utils/cmsis/sam4s/source/templates; ../../../../drivers/uart; ../../../../utils; ../..; ../../../../drivers/tc; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../../common/boards; ../../../../drivers/pio; ../../../../boards/sam4s_xplained; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sam4s_xplained_qtouch_demo_flash.bin
  ILINK.IlinkOutputFile: sam4s_xplained_qtouch_demo_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/qtouch/generic/sam/qtouch/lib/iar
    ../../../../../thirdparty/qtouch/generic/sam/qtouch/lib/iar/: libsam4s-32qt-k-8rs-iar.a
  group thirdparty/qtouch/generic/sam/qtouch/common
    ../../../../../thirdparty/qtouch/generic/sam/qtouch/common/: BitBangSPI_Master.c
  group thirdparty/qtouch/qdebug
    ../../../../../thirdparty/qtouch/qdebug/: QDebug.c QDebugTransport.c
  group sam/applications/sam4s_xplained_qtouch_demo
    ../../: qtouch_demo.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../utils/cmsis/sam4s/source/templates/: exceptions.c system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c
  group sam/drivers/tc
    ../../../../drivers/tc/: tc.c
  group sam/drivers/wdt
    ../../../../drivers/wdt/: wdt.c
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c
  group sam/boards/sam4s_xplained
    ../../../../boards/sam4s_xplained/: led.c
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/clock/sam4s
    ../../../../../common/services/clock/sam4s/: sysclk.c
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c
