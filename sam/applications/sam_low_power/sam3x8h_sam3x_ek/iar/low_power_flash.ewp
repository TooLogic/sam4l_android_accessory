# IAR project low_power_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3X_EK; __SAM3X8H__
  ICCARM.CCIncludePath2: ../../../../drivers/adc; ../../../../../common/services/serial/sam_uart; ../../../../utils/preprocessor; ../..; ../../../../drivers/pmc; ../../../../boards/sam3x_ek; ../../../../utils/cmsis/sam3x/source/templates; ../../../../drivers/efc; ../../../../../common/services/serial; ../../../../drivers/gpbr; ../../../../utils/cmsis/sam3x/include; ../../../../drivers/supc; ../../../../../common/utils; ../../../../drivers/wdt; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../../common/services/gpio; ../../../../drivers/uart; ../../../../utils; ..; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../../common/boards; ../../../../drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM3X_EK; __SAM3X8H__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: low_power_flash.bin
  ILINK.IlinkOutputFile: low_power_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/supc
    ../../../../drivers/supc/: supc.c
  group sam/drivers/efc
    ../../../../drivers/efc/: efc.c
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c
  group sam/drivers/wdt
    ../../../../drivers/wdt/: wdt.c
  group sam/drivers/adc
    ../../../../drivers/adc/: adc.c adc_sam3u.c
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c
  group sam/drivers/gpbr
    ../../../../drivers/gpbr/: gpbr.c
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../utils/cmsis/sam3x/source/templates/: exceptions.c system_sam3x.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/applications/sam_low_power
    ../../: main.c
  group sam/applications/sam_low_power/sam3x8h_sam3x_ek
    ../: low_power_board.c
  group sam/boards/sam3x_ek
    ../../../../boards/sam3x_ek/: led.c init.c
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/services/clock/sam3x
    ../../../../../common/services/clock/sam3x/: sysclk.c
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c
