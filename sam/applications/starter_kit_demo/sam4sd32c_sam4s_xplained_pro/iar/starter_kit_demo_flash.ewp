# IAR project starter_kit_demo_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4SD32C Atmel SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4S_XPLAINED_PRO; ARM_MATH_CM4=true; __SAM4SD32C__
  ICCARM.CCIncludePath2: ../../../../drivers/adc; ../..; ../../../../../common/services/spi/sam_spi; ../../../../../common/components/memory/sd_mmc; ../../../../utils/preprocessor; ../../../../drivers/pmc; ../../../../utils/cmsis/sam4s/include; ../../../../utils/header_files; ../../../../drivers/efc; ../../../../../common/services/twi; ../../../../../common/components/memory/eeprom/at30tse75x; ../../../../../common/services/serial; ../../../../drivers/gpbr; ..; ../../../../drivers/spi; ../../../../drivers/supc; ../../../../../common/utils; ../../../../drivers/wdt; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../../common/services/gpio; ../../../../utils/cmsis/sam4s/source/templates; ../../../../../common/services/delay; ../../../../drivers/uart; ../../../../utils; ../../../../drivers/usart; ../../../../../common/services/serial/sam_uart; ../../../../../common/boards; ../../../../../common/services/ioport; ../../../../drivers/pio; ../../../../../common/components/display/ssd1306; ../../../../boards/sam4s_xplained_pro; ../../../../../common/services/spi; ../../../../drivers/twi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4S_XPLAINED_PRO; ARM_MATH_CM4=true; __SAM4SD32C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: starter_kit_demo_flash.bin
  ILINK.IlinkOutputFile: starter_kit_demo_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam4s/sam4sd32/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/supc
    ../../../../drivers/supc/: supc.c
  group sam/drivers/efc
    ../../../../drivers/efc/: efc.c
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c
  group sam/drivers/adc
    ../../../../drivers/adc/: adc.c adc_sam3u.c
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c
  group sam/drivers/twi
    ../../../../drivers/twi/: twi.c
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/spi
    ../../../../drivers/spi/: spi.c
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c
  group sam/drivers/gpbr
    ../../../../drivers/gpbr/: gpbr.c
  group sam/drivers/wdt
    ../../../../drivers/wdt/: wdt.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../utils/cmsis/sam4s/source/templates/: exceptions.c system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/boards/sam4s_xplained_pro
    ../../../../boards/sam4s_xplained_pro/: init.c
  group sam/applications/starter_kit_demo
    ../../: main.c
  group common/services/delay/sam
    ../../../../../common/services/delay/sam/: cycle_counter.c
  group common/services/spi/sam_spi
    ../../../../../common/services/spi/sam_spi/: spi_master.c
  group common/services/clock/sam4s
    ../../../../../common/services/clock/sam4s/: sysclk.c
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c
  group common/components/display/ssd1306
    ../../../../../common/components/display/ssd1306/: font.c ssd1306.c
  group common/components/memory/sd_mmc
    ../../../../../common/components/memory/sd_mmc/: sd_mmc.c sd_mmc_spi.c
  group common/components/memory/eeprom/at30tse75x
    ../../../../../common/components/memory/eeprom/at30tse75x/: at30tse75x.c
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
