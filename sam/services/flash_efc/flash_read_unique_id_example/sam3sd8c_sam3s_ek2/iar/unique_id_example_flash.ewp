# IAR project unique_id_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3SD8 Atmel SAM3SD8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3SD8C__; BOARD=SAM3S_EK2
  ICCARM.CCIncludePath2: ../../../../../boards/sam3s_ek2; ../../../../../../common/services/serial/sam_uart; ../../../../../drivers/uart; ../../../../../boards; ../../../../../utils; ../../../../../utils/cmsis/sam3s8/source/templates; ..; ../../../../../drivers/usart; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../utils/preprocessor; ../../../../../../common/services/clock; ../../../../../drivers/pmc; ../../..; ../../../../../utils/cmsis/sam3s8/include; ../../../../../drivers/pio; ../../../../../../common/utils; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/services/gpio; ../../../../../../common/services/serial; ../../../../../drivers/efc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3SD8C__; BOARD=SAM3S_EK2
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: unique_id_example_flash.bin
  ILINK.IlinkOutputFile: unique_id_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3s/sam3sd8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: sleep.c pmc.c
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c
  group sam/drivers/usart
    ../../../../../drivers/usart/: usart.c
  group sam/drivers/efc
    ../../../../../drivers/efc/: efc.c
  group sam/services/flash_efc
    ../../../: flash_efc.c
  group sam/services/flash_efc/flash_read_unique_id_example
    ../../: flash_read_unique_id_example.c
  group sam/boards/sam3s_ek2
    ../../../../../boards/sam3s_ek2/: led.c init.c
  group sam/utils/cmsis/sam3s8/source/templates
    ../../../../../utils/cmsis/sam3s8/source/templates/: exceptions.c system_sam3sd8.c
  group sam/utils/cmsis/sam3s8/source/templates/iar
    ../../../../../utils/cmsis/sam3s8/source/templates/iar/: startup_sam3sd8.c
  group common/services/clock/sam3s
    ../../../../../../common/services/clock/sam3s/: sysclk.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
