# IAR project unique_id_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3N4 Atmel SAM3N4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3N_EK; __SAM3N4C__
  ICCARM.CCIncludePath2: ..; ../../../../../../common/services/serial/sam_uart; ../../../../../drivers/uart; ../../../../../utils; ../../../../../utils/cmsis/sam3n/source/templates; ../../../../../boards; ../../../../../drivers/usart; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../utils/preprocessor; ../../../../../../common/services/clock; ../../../../../utils/cmsis/sam3n/include; ../../../../../drivers/pmc; ../../..; ../../../../../drivers/pio; ../../../../../boards/sam3n_ek; ../../../../../../common/utils; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/services/gpio; ../../../../../../common/services/serial; ../../../../../drivers/efc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM3N_EK; __SAM3N4C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: unique_id_example_flash.bin
  ILINK.IlinkOutputFile: unique_id_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3n/sam3n4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c
  group sam/drivers/efc
    ../../../../../drivers/efc/: efc.c
  group sam/drivers/usart
    ../../../../../drivers/usart/: usart.c
  group sam/utils/cmsis/sam3n/source/templates
    ../../../../../utils/cmsis/sam3n/source/templates/: system_sam3n.c exceptions.c
  group sam/utils/cmsis/sam3n/source/templates/iar
    ../../../../../utils/cmsis/sam3n/source/templates/iar/: startup_sam3n.c
  group sam/boards/sam3n_ek
    ../../../../../boards/sam3n_ek/: init.c led.c
  group sam/services/flash_efc
    ../../../: flash_efc.c
  group sam/services/flash_efc/flash_read_unique_id_example
    ../../: flash_read_unique_id_example.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam3n
    ../../../../../../common/services/clock/sam3n/: sysclk.c
