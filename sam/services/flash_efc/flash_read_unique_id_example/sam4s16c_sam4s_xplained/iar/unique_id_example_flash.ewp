# IAR project unique_id_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4S16C__; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  ICCARM.CCIncludePath2: ../../../../../utils/cmsis/sam4s/source/templates; ../../../../../../common/services/serial/sam_uart; ../../../../../drivers/uart; ../../../../../utils; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../drivers/usart; ../../../../../utils/header_files; ..; ../../../../../utils/preprocessor; ../../../../../../common/boards; ../../../../../drivers/pmc; ../../..; ../../../../../boards/sam4s_xplained; ../../../../../drivers/pio; ../../../../../../common/utils; ../../../../../utils/cmsis/sam4s/include; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/services/gpio; ../../../../../../common/services/serial; ../../../../../drivers/efc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4S16C__; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: unique_id_example_flash.bin
  ILINK.IlinkOutputFile: unique_id_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c
  group sam/drivers/usart
    ../../../../../drivers/usart/: usart.c
  group sam/drivers/efc
    ../../../../../drivers/efc/: efc.c
  group sam/boards/sam4s_xplained
    ../../../../../boards/sam4s_xplained/: init.c led.c
  group sam/services/flash_efc
    ../../../: flash_efc.c
  group sam/services/flash_efc/flash_read_unique_id_example
    ../../: flash_read_unique_id_example.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../utils/cmsis/sam4s/source/templates/: system_sam4s.c exceptions.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam4s
    ../../../../../../common/services/clock/sam4s/: sysclk.c
