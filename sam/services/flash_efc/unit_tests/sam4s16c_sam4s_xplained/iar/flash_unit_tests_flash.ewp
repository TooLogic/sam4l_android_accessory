# IAR project flash_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; __SAM4S16C__; TEST_SUITE_DEFINE_ASSERT_MACRO; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  ICCARM.CCIncludePath2: ../../../../../../common/services/serial/sam_uart; ../../../../../utils/preprocessor; ../../../../../drivers/pio; ../../../../../utils/cmsis/sam4s/include; ../../../../../drivers/efc; ../../../../../../common/services/serial; ../../..; ../../../../../../common/utils; ..; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/services/gpio; ../../../../../utils/cmsis/sam4s/source/templates; ../../../../../drivers/uart; ../../../../../utils; ../..; ../../../../../drivers/usart; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../drivers/pmc; ../../../../../boards/sam4s_xplained; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: flash_unit_tests_flash.bin
  ILINK.IlinkOutputFile: flash_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: sleep.c pmc.c
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c
  group sam/drivers/usart
    ../../../../../drivers/usart/: usart.c
  group sam/drivers/efc
    ../../../../../drivers/efc/: efc.c
  group sam/boards/sam4s_xplained
    ../../../../../boards/sam4s_xplained/: init.c led.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../utils/cmsis/sam4s/source/templates/: system_sam4s.c exceptions.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/services/flash_efc
    ../../../: flash_efc.c
  group sam/services/flash_efc/unit_tests
    ../../: unit_tests.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam4s
    ../../../../../../common/services/clock/sam4s/: sysclk.c
