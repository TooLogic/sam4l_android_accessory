# IAR project resistive_touch_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3X_EK; __SAM3X8H__
  ICCARM.CCIncludePath2: ../../../../../utils/header_files; ../../../../../../common/services/spi/sam_spi; ..; ../../../../../utils/preprocessor; ../../../../../drivers/pio; ../../../../../boards/sam3x_ek; ../..; ../../../../../utils/cmsis/sam3x/source/templates; ../../../../../drivers/ebi/smc; ../../../../../../common/services/serial; ../../../../../utils/cmsis/sam3x/include; ../../../../../drivers/spi; ../../../../../../common/utils; ../../../../../components/resistive_touch/ads7843; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../components/display/aat31xx; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/services/gpio; ../../../../../drivers/uart; ../../../../../utils; ../../../../../drivers/usart; ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../..; ../../../../../drivers/pmc; ../../../../../components/display/hx8347a; ../../../../../../common/services/spi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM3X_EK; __SAM3X8H__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: resistive_touch_example_flash.bin
  ILINK.IlinkOutputFile: resistive_touch_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/clock/sam3x
    ../../../../../../common/services/clock/sam3x/: sysclk.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/spi/sam_spi
    ../../../../../../common/services/spi/sam_spi/: spi_master.c
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../utils/cmsis/sam3x/source/templates/: exceptions.c system_sam3x.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/drivers/usart
    ../../../../../drivers/usart/: usart.c
  group sam/drivers/spi
    ../../../../../drivers/spi/: spi.c
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/ebi/smc
    ../../../../../drivers/ebi/smc/: smc.c
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c
  group sam/boards/sam3x_ek
    ../../../../../boards/sam3x_ek/: init.c led.c
  group sam/services/resistive_touch
    ../../../: rtouch.c
  group sam/services/resistive_touch/example
    ../../: rtouch_calibrate.c ads7843_example.c
  group sam/components/display/aat31xx
    ../../../../../components/display/aat31xx/: aat31xx.c
  group sam/components/display/hx8347a
    ../../../../../components/display/hx8347a/: hx8347a.c
  group sam/components/resistive_touch/ads7843
    ../../../../../components/resistive_touch/ads7843/: ads7843.c
