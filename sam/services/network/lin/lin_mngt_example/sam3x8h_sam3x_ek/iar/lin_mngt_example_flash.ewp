# IAR project lin_mngt_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3X_EK; __SAM3X8H__
  ICCARM.CCIncludePath2: ../../../../../../../common/services/serial/sam_uart; ../../../../../../utils/preprocessor; ../../../../../../drivers/pio; ../../../../../../boards/sam3x_ek; ../../../../../../drivers/pmc; ../../../../../../utils/cmsis/sam3x/source/templates; ../../../../../../../common/services/serial; ../../../../../../utils/cmsis/sam3x/include; ../../../../../../drivers/pdc; ../../../../../../../common/utils; ../../../../../../../common/services/clock; ../../../../../../boards; ../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../common/services/gpio; ..; ../../../../../../drivers/uart; ../../../../../../utils; ../../../../../../drivers/tc; ../../../../../../drivers/usart; ../../../../../../utils/header_files; ../../../../../../../common/boards; ../../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM3X_EK; __SAM3X8H__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: lin_mngt_example_flash.bin
  ILINK.IlinkOutputFile: lin_mngt_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/services/network/lin
    ../../../: lin.c
  group sam/services/network/lin/lin_mngt_example
    ../../: lin_mngt_example.c
  group sam/drivers/pio
    ../../../../../../drivers/pio/: pio.c pio_handler.c
  group sam/drivers/pmc
    ../../../../../../drivers/pmc/: sleep.c pmc.c
  group sam/drivers/usart
    ../../../../../../drivers/usart/: usart.c
  group sam/drivers/pdc
    ../../../../../../drivers/pdc/: pdc.c
  group sam/drivers/tc
    ../../../../../../drivers/tc/: tc.c
  group sam/drivers/uart
    ../../../../../../drivers/uart/: uart.c
  group sam/boards/sam3x_ek
    ../../../../../../boards/sam3x_ek/: led.c init.c
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../utils/cmsis/sam3x/source/templates/: exceptions.c system_sam3x.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group common/services/clock/sam3x
    ../../../../../../../common/services/clock/sam3x/: sysclk.c
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
