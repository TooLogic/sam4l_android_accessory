# IAR project adcife_adcife_wm_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../../../../utils/preprocessor; ../../../../pdca; ../../../../../utils/cmsis/sam4l/include; ../../../../../utils/cmsis/sam4l/source/templates; ../../../../../../common/services/serial; ../../../../../../common/services/clock; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../../boards/sam4l_ek; ..; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/services/delay; ../../../../../utils; ../../../../dacc; ../..; ../../../../usart; ../../../../../utils/header_files; ../../../../flashcalw; ../../../../../../common/services/ioport; ../../../../bpm; ../../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: adcife_adcife_wm_example_flash.bin
  ILINK.IlinkOutputFile: adcife_adcife_wm_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/clock/sam4l
    ../../../../../../common/services/clock/sam4l/: pll.c osc.c sysclk.c dfll.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c
  group common/services/sleepmgr/sam4l
    ../../../../../../common/services/sleepmgr/sam4l/: sleepmgr.c
  group sam/drivers/flashcalw
    ../../../../flashcalw/: flashcalw.c
  group sam/drivers/bpm
    ../../../../bpm/: bpm.c
  group sam/drivers/pdca
    ../../../../pdca/: pdca.c
  group sam/drivers/dacc
    ../../../../dacc/: dacc.c
  group sam/drivers/adcife
    ../../../: adcife.c
  group sam/drivers/adcife/adcife_wm_example
    ../../: adcife_wm_example.c
  group sam/drivers/usart
    ../../../../usart/: usart.c
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../utils/cmsis/sam4l/source/templates/: exceptions.c system_sam4l.c
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/boards/sam4l_ek
    ../../../../../boards/sam4l_ek/: init.c board_monitor.c
