# IAR project flashcalw_example1_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../utils/cmsis/sam4l/source/templates; ../../../../../../common/services/delay; ../../../../../utils; ../../../../../../common/services/clock; ../../../../../boards; ../../../../usart; ../../../../../../common/services/serial; ../../..; ../../../../../utils/preprocessor; ../../../../../../common/boards; ../../../../../boards/sam4l_ek; ../../../../../../common/services/ioport; ../../../../../../common/services/serial/sam_uart; ../../../../bpm; ../../../../../../common/utils; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../utils/header_files; ../../../../../utils/cmsis/sam4l/include; ..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: flashcalw_example1_flash.bin
  ILINK.IlinkOutputFile: flashcalw_example1_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../utils/cmsis/sam4l/source/templates/: system_sam4l.c exceptions.c
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/boards/sam4l_ek
    ../../../../../boards/sam4l_ek/: board_monitor.c init.c
  group sam/drivers/flashcalw
    ../../../: flashcalw.c
  group sam/drivers/flashcalw/flash_example1
    ../../: flashcalw_example1.c
  group sam/drivers/usart
    ../../../../usart/: usart.c
  group sam/drivers/bpm
    ../../../../bpm/: bpm.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam4l
    ../../../../../../common/services/clock/sam4l/: osc.c pll.c sysclk.c dfll.c
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c
