# IAR project rtt_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3U4E__; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../../../common/utils/stdio/stdio_serial; ../../../../uart; ../../..; ../..; ../../../../../../common/services/clock; ../../../../../../common/services/gpio; ../../../../usart; ../../../../../../common/services/serial; ../../../../../../common/boards; ../../../../../utils/preprocessor; ..; ../../../../../utils/cmsis/sam3u/include; ../../../../pio; ../../../../../boards; ../../../../../utils/cmsis/sam3u/source/templates; ../../../../../../common/utils; ../../../../../boards/sam3u_ek; ../../../../../utils/header_files; ../../../../pmc; ../../../../../utils; ../../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3U4E__; BOARD=SAM3U_EK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rtt_example_flash.bin
  ILINK.IlinkOutputFile: rtt_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group sam/boards/sam3u_ek
    ../../../../../boards/sam3u_ek/: led.c init.c
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../utils/cmsis/sam3u/source/templates/: system_sam3u.c exceptions.c
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/pio
    ../../../../pio/: pio.c pio_handler.c
  group sam/drivers/rtt
    ../../../: rtt.c
  group sam/drivers/rtt/example
    ../../: rtt_example.c
  group sam/drivers/pmc
    ../../../../pmc/: pmc.c sleep.c
  group sam/drivers/usart
    ../../../../usart/: usart.c
  group common/services/clock/sam3u
    ../../../../../../common/services/clock/sam3u/: sysclk.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
