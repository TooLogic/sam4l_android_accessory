# IAR project spi_spi_dmac_slave_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4E16E Atmel SAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  ICCARM.CCIncludePath2: ..; ../../../../../utils/header_files; ../../../../uart; ../../../../../utils; ../../../../../utils/fpu; ../../../../../boards; ../../../../usart; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/boards; ../../../../../utils/preprocessor; ../../../../dmac; ../../../../../../common/services/clock; ../../../../../../common/services/ioport; ../../../../pmc; ../../..; ../../../../../utils/cmsis/sam4e/source/templates; ../../../../../utils/cmsis/sam4e/include; ../../../../../../common/utils; ../../../../../boards/sam4e_ek; ../../../../../../common/services/serial; ../../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: spi_spi_dmac_slave_example_flash.bin
  ILINK.IlinkOutputFile: spi_spi_dmac_slave_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4e/sam4e16e/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../utils/cmsis/sam4e/source/templates/: system_sam4e.c exceptions.c
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/drivers/spi
    ../../../: spi.c
  group sam/drivers/spi/spi_dmac_slave_example
    ../../: spi_dmac_slave_example.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/pmc
    ../../../../pmc/: sleep.c pmc.c
  group sam/drivers/usart
    ../../../../usart/: usart.c
  group sam/drivers/dmac
    ../../../../dmac/: dmac.c
  group sam/boards/sam4e_ek
    ../../../../../boards/sam4e_ek/: init.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam4e
    ../../../../../../common/services/clock/sam4e/: sysclk.c
