# IAR project spi_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4E16E Atmel SAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  ICCARM.CCIncludePath2: ../../../../../utils/header_files; ../../../../uart; ../../../../../utils; ../../../../../utils/fpu; ../../../../../boards; ../../../../usart; ../..; ../../../../../../common/boards; ../../../../../utils/preprocessor; ..; ../../../../../../common/services/clock; ../../../../../../common/services/ioport; ../../../../pmc; ../../..; ../../../../../utils/cmsis/sam4e/source/templates; ../../../../../utils/cmsis/sam4e/include; ../../../../../../common/utils; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/services/serial; ../../../../../boards/sam4e_ek; ../../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: spi_unit_tests_flash.bin
  ILINK.IlinkOutputFile: spi_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4e/sam4e16e/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../utils/cmsis/sam4e/source/templates/: system_sam4e.c exceptions.c
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/boards/sam4e_ek
    ../../../../../boards/sam4e_ek/: init.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/spi
    ../../../: spi.c
  group sam/drivers/spi/unit_tests
    ../../: unit_tests.c
  group sam/drivers/pmc
    ../../../../pmc/: sleep.c pmc.c
  group sam/drivers/usart
    ../../../../usart/: usart.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/clock/sam4e
    ../../../../../../common/services/clock/sam4e/: sysclk.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
