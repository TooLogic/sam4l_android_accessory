# IAR project wdt_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3X8E__; BOARD=ARDUINO_DUE_X
  ICCARM.CCIncludePath2: ../../..; ../../../../../utils/header_files; ../../../../uart; ..; ../../../../../utils; ../../../../../../common/services/clock; ../../../../../boards; ../../../../usart; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/boards; ../../../../../utils/preprocessor; ../../../../../utils/cmsis/sam3x/include; ../../../../pio; ../../../../../boards/arduino_due_x; ../../../../pmc; ../../../../../../common/utils; ../..; ../../../../../../common/services/gpio; ../../../../../../common/services/serial; ../../../../../utils/cmsis/sam3x/source/templates; ../../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3X8E__; BOARD=ARDUINO_DUE_X
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: wdt_example_flash.bin
  ILINK.IlinkOutputFile: wdt_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam3x
    ../../../../../../common/services/clock/sam3x/: sysclk.c
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../utils/cmsis/sam3x/source/templates/: system_sam3x.c exceptions.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/drivers/usart
    ../../../../usart/: usart.c
  group sam/drivers/wdt
    ../../../: wdt.c
  group sam/drivers/wdt/example
    ../../: wdt_example.c
  group sam/drivers/pmc
    ../../../../pmc/: sleep.c pmc.c
  group sam/drivers/pio
    ../../../../pio/: pio.c pio_handler.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/boards/arduino_due_x
    ../../../../../boards/arduino_due_x/: init.c led.c
