# IAR project gloc_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; BOARD=USER_BOARD; TEST_SUITE_DEFINE_ASSERT_MACRO; __SAM4LC4C__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../common/boards/user_board; ../../../../../utils/cmsis/sam4l/source/templates; ../../../../../../common/services/delay; ../../../../../utils; ../../..; ../../../../../../common/services/clock; ../../../../../../common/boards; ../../../../usart; ../../../../../utils/header_files; ../../../../flashcalw; ..; ../../../../../utils/preprocessor; ../../../../../../common/services/sleepmgr; ../../../../../../common/services/ioport; ../..; ../../../../../../common/utils; ../../../../bpm; ../../../../../../common/services/serial; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../utils/cmsis/sam4l/include; ../../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: gloc_unit_tests_flash.bin
  ILINK.IlinkOutputFile: gloc_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../utils/cmsis/sam4l/source/templates/: system_sam4l.c exceptions.c
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/drivers/usart
    ../../../../usart/: usart.c
  group sam/drivers/gloc
    ../../../: gloc.c
  group sam/drivers/gloc/unit_tests
    ../../: unit_tests.c
  group sam/drivers/gloc/unit_tests/sam4lc4c_sam4l_user_board_gloc
    ../: init.c
  group sam/drivers/flashcalw
    ../../../../flashcalw/: flashcalw.c
  group sam/drivers/bpm
    ../../../../bpm/: bpm.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam4l
    ../../../../../../common/services/clock/sam4l/: osc.c pll.c sysclk.c dfll.c
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c
  group common/services/sleepmgr/sam4l
    ../../../../../../common/services/sleepmgr/sam4l/: sleepmgr.c
