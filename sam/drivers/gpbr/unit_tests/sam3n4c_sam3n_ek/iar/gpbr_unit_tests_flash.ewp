# IAR project gpbr_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3N4 Atmel SAM3N4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; BOARD=SAM3N_EK; TEST_SUITE_DEFINE_ASSERT_MACRO; __SAM3N4C__
  ICCARM.CCIncludePath2: ../../../../../../common/services/serial/sam_uart; ../../../../../utils/preprocessor; ../../../../pmc; ../../../../efc; ../../../../../../common/services/serial; ../../..; ../../../../../utils/cmsis/sam3n/include; ../../../../../services/flash_efc; ../../../../supc; ../../../../../../common/utils; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../boards/sam3n_ek; ../../../../../../common/services/gpio; ../../../../uart; ../../../../rtt; ../../../../../utils; ../../../../../utils/cmsis/sam3n/source/templates; ../../../../usart; ../../../../../utils/header_files; ../../../../../../common/boards; ..; ../../../../pio; ../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: gpbr_unit_tests_flash.bin
  ILINK.IlinkOutputFile: gpbr_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3n/sam3n4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/clock/sam3n
    ../../../../../../common/services/clock/sam3n/: sysclk.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group sam/services/flash_efc
    ../../../../../services/flash_efc/: flash_efc.c
  group sam/drivers/gpbr
    ../../../: gpbr.c
  group sam/drivers/gpbr/unit_tests
    ../../: unit_tests.c
  group sam/drivers/rtt
    ../../../../rtt/: rtt.c
  group sam/drivers/efc
    ../../../../efc/: efc.c
  group sam/drivers/pmc
    ../../../../pmc/: sleep.c pmc.c
  group sam/drivers/pio
    ../../../../pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/supc
    ../../../../supc/: supc.c
  group sam/drivers/usart
    ../../../../usart/: usart.c
  group sam/utils/cmsis/sam3n/source/templates
    ../../../../../utils/cmsis/sam3n/source/templates/: exceptions.c system_sam3n.c
  group sam/utils/cmsis/sam3n/source/templates/iar
    ../../../../../utils/cmsis/sam3n/source/templates/iar/: startup_sam3n.c
  group sam/boards/sam3n_ek
    ../../../../../boards/sam3n_ek/: led.c init.c
