# IAR project supc_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; __SAM3U4E__; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../../utils/header_files; ../../../../uart; ../../../../../utils/cmsis/sam3u/source/templates; ../../../../../utils; ../../../../../../common/services/clock; ../../../../../boards; ../../../../usart; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/boards; ../../../../../utils/preprocessor; ../..; ../../../../../utils/cmsis/sam3u/include; ..; ../../../../pmc; ../../../../pio; ../../..; ../../../../../../common/utils; ../../../../../boards/sam3u_ek; ../../../../../../common/services/gpio; ../../../../../../common/services/serial; ../../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: supc_unit_tests_flash.bin
  ILINK.IlinkOutputFile: supc_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/clock/sam3u
    ../../../../../../common/services/clock/sam3u/: sysclk.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group sam/boards/sam3u_ek
    ../../../../../boards/sam3u_ek/: init.c led.c
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../utils/cmsis/sam3u/source/templates/: system_sam3u.c exceptions.c
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/supc
    ../../../: supc.c
  group sam/drivers/supc/unit_tests
    ../../: unit_tests.c
  group sam/drivers/pmc
    ../../../../pmc/: pmc.c sleep.c
  group sam/drivers/pio
    ../../../../pio/: pio_handler.c pio.c
  group sam/drivers/usart
    ../../../../usart/: usart.c
