# IAR project pwm_pwm_sync_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4E16E Atmel SAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  ICCARM.CCIncludePath2: ../../../../../../common/services/serial/sam_uart; ../../../../../utils/preprocessor; ../../..; ../../../../pio; ../../../../../utils/fpu; ../../../../../../common/services/serial; ../../../../../utils/cmsis/sam4e/source/templates; ../../../../pdc; ../../../../../../common/utils; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../utils/cmsis/sam4e/include; ../../../../../../common/services/gpio; ..; ../../../../uart; ../../../../../utils; ../../../../usart; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../pmc; ../../../../../boards/sam4e_ek; ../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: pwm_pwm_sync_example_flash.bin
  ILINK.IlinkOutputFile: pwm_pwm_sync_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4e/sam4e16e/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../utils/cmsis/sam4e/source/templates/: system_sam4e.c exceptions.c
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/drivers/pwm
    ../../../: pwm.c
  group sam/drivers/pwm/pwm_sync_example
    ../../: pwm_sync_example.c
  group sam/drivers/pdc
    ../../../../pdc/: pdc.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/pio
    ../../../../pio/: pio.c pio_handler.c
  group sam/drivers/pmc
    ../../../../pmc/: sleep.c pmc.c
  group sam/drivers/usart
    ../../../../usart/: usart.c
  group sam/boards/sam4e_ek
    ../../../../../boards/sam4e_ek/: init.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam4e
    ../../../../../../common/services/clock/sam4e/: sysclk.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
