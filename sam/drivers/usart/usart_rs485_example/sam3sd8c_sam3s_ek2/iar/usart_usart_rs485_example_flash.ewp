# IAR project usart_usart_rs485_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3SD8 Atmel SAM3SD8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3SD8C__; BOARD=SAM3S_EK2
  ICCARM.CCIncludePath2: ../../../../../../common/services/gpio; ../../../../../utils/header_files; ../../../../uart; ../../../../../utils; ../../../../../utils/cmsis/sam3s8/source/templates; ../../../../../boards; ../../..; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/boards; ../../../../../utils/preprocessor; ../..; ../../../../../../common/services/clock; ..; ../../../../pio; ../../../../../utils/cmsis/sam3s8/include; ../../../../pdc; ../../../../../../common/utils; ../../../../../boards/sam3s_ek2; ../../../../pmc; ../../../../../../common/services/serial; ../../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3SD8C__; BOARD=SAM3S_EK2
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: usart_usart_rs485_example_flash.bin
  ILINK.IlinkOutputFile: usart_usart_rs485_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3s/sam3sd8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/clock/sam3s
    ../../../../../../common/services/clock/sam3s/: sysclk.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group sam/drivers/pdc
    ../../../../pdc/: pdc.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/pmc
    ../../../../pmc/: sleep.c pmc.c
  group sam/drivers/pio
    ../../../../pio/: pio.c pio_handler.c
  group sam/drivers/usart
    ../../../: usart.c
  group sam/drivers/usart/usart_rs485_example
    ../../: usart_rs485_example_pdc.c
  group sam/utils/cmsis/sam3s8/source/templates
    ../../../../../utils/cmsis/sam3s8/source/templates/: system_sam3sd8.c exceptions.c
  group sam/utils/cmsis/sam3s8/source/templates/iar
    ../../../../../utils/cmsis/sam3s8/source/templates/iar/: startup_sam3sd8.c
  group sam/boards/sam3s_ek2
    ../../../../../boards/sam3s_ek2/: init.c led.c
