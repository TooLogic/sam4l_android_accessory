# IAR project usart_usart_hard_handshaking_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3X_EK; __SAM3X8H__
  ICCARM.CCIncludePath2: ../../../../../../common/services/serial/sam_uart; ../../../../../utils/preprocessor; ../../../../pmc; ../../../../../boards/sam3x_ek; ../../../../../utils/cmsis/sam3x/source/templates; ../../../../../../common/services/serial; ../../../../../utils/cmsis/sam3x/include; ../../../../pdc; ../../../../../../common/utils; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../..; ../../../../../../common/services/gpio; ..; ../../../../uart; ../../../../../utils; ../../../../tc; ../../..; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM3X_EK; __SAM3X8H__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: usart_usart_hard_handshaking_example_flash.bin
  ILINK.IlinkOutputFile: usart_usart_hard_handshaking_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/usart
    ../../../: usart.c
  group sam/drivers/usart/usart_hard_handshaking_example
    ../../: usart_hard_handshaking_example.c
  group sam/drivers/pdc
    ../../../../pdc/: pdc.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/tc
    ../../../../tc/: tc.c
  group sam/drivers/pmc
    ../../../../pmc/: sleep.c pmc.c
  group sam/drivers/pio
    ../../../../pio/: pio.c pio_handler.c
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../utils/cmsis/sam3x/source/templates/: system_sam3x.c exceptions.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/boards/sam3x_ek
    ../../../../../boards/sam3x_ek/: init.c led.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam3x
    ../../../../../../common/services/clock/sam3x/: sysclk.c
