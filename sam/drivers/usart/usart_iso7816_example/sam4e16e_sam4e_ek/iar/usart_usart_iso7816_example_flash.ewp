# IAR project usart_usart_iso7816_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4E16E Atmel SAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SMART_CARD_USING_IOPORT; BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  ICCARM.CCIncludePath2: ../../../../../utils/header_files; ../../../../uart; ../../../../../utils; ../../../../../../common/services/serial; ../../../../../utils/fpu; ../../../../../boards; ../../..; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/boards; ../../../../../utils/preprocessor; ../../../../../../common/services/clock; ..; ../../../../pmc; ../../../../../utils/cmsis/sam4e/source/templates; ../../../../../utils/cmsis/sam4e/include; ../../../../../../common/utils; ../../../../../services/smart_card; ../..; ../../../../../../common/services/ioport; ../../../../../boards/sam4e_ek; ../../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: usart_usart_iso7816_example_flash.bin
  ILINK.IlinkOutputFile: usart_usart_iso7816_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4e/sam4e16e/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../utils/cmsis/sam4e/source/templates/: system_sam4e.c exceptions.c
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/boards/sam4e_ek
    ../../../../../boards/sam4e_ek/: init.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/pmc
    ../../../../pmc/: pmc.c sleep.c
  group sam/drivers/usart
    ../../../: usart.c
  group sam/drivers/usart/usart_iso7816_example
    ../../: usart_iso7816_example.c
  group sam/services/smart_card
    ../../../../../services/smart_card/: iso7816.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam4e
    ../../../../../../common/services/clock/sam4e/: sysclk.c
