# IAR project usart_usart_iso7816_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4SD32C Atmel SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4S_EK2; SMART_CARD_USING_GPIO; ARM_MATH_CM4=true; __SAM4SD32C__
  ICCARM.CCIncludePath2: ../../../../../utils/cmsis/sam4s/source/templates; ../../../../../../common/services/serial/sam_uart; ../../../../uart; ../../../../../utils; ../../../../../../common/services/clock; ../../../../../boards; ../../..; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../utils/preprocessor; ../../../../../boards/sam4s_ek2; ../../../../pmc; ../../../../pio; ../../../../../../common/utils; ../../../../../services/smart_card; ../../../../../utils/cmsis/sam4s/include; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/services/gpio; ../../../../../../common/services/serial; ..; ../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: usart_usart_iso7816_example_flash.bin
  ILINK.IlinkOutputFile: usart_usart_iso7816_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4s/sam4sd32/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam4s
    ../../../../../../common/services/clock/sam4s/: sysclk.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../utils/cmsis/sam4s/source/templates/: system_sam4s.c exceptions.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/boards/sam4s_ek2
    ../../../../../boards/sam4s_ek2/: init.c led.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/pmc
    ../../../../pmc/: pmc.c sleep.c
  group sam/drivers/pio
    ../../../../pio/: pio_handler.c pio.c
  group sam/drivers/usart
    ../../../: usart.c
  group sam/drivers/usart/usart_iso7816_example
    ../../: usart_iso7816_example.c
  group sam/services/smart_card
    ../../../../../services/smart_card/: iso7816.c
