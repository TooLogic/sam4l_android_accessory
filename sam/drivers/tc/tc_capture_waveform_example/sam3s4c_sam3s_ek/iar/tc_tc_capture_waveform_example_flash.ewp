# IAR project tc_tc_capture_waveform_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3S4C__; BOARD=SAM3S_EK
  ICCARM.CCIncludePath2: ../../../../../utils/header_files; ../../../../uart; ../../../../../boards; ../../../../../utils; ../../../../../boards/sam3s_ek; ../../../../../../common/services/clock; ../../..; ../../../../usart; ../../../../../utils/cmsis/sam3s/include; ../../../../../../common/boards; ../../../../../utils/preprocessor; ../../../../pmc; ../../../../pio; ../..; ..; ../../../../../../common/utils; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../utils/cmsis/sam3s/source/templates; ../../../../../../common/services/gpio; ../../../../../../common/services/serial; ../../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3S4C__; BOARD=SAM3S_EK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tc_tc_capture_waveform_example_flash.bin
  ILINK.IlinkOutputFile: tc_tc_capture_waveform_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3s/sam3s4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam3s/source/templates
    ../../../../../utils/cmsis/sam3s/source/templates/: system_sam3s.c exceptions.c
  group sam/utils/cmsis/sam3s/source/templates/iar
    ../../../../../utils/cmsis/sam3s/source/templates/iar/: startup_sam3s.c
  group sam/drivers/usart
    ../../../../usart/: usart.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/pio
    ../../../../pio/: pio.c pio_handler.c
  group sam/drivers/pmc
    ../../../../pmc/: pmc.c sleep.c
  group sam/drivers/tc
    ../../../: tc.c
  group sam/drivers/tc/tc_capture_waveform_example
    ../../: tc_capture_waveform_example.c
  group sam/boards/sam3s_ek
    ../../../../../boards/sam3s_ek/: led.c init.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/clock/sam3s
    ../../../../../../common/services/clock/sam3s/: sysclk.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
