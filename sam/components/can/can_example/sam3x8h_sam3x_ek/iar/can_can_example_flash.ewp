# IAR project can_can_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3X_EK; __SAM3X8H__
  ICCARM.CCIncludePath2: ../../../../../../common/services/serial/sam_uart; ../../../../../utils/preprocessor; ../../../../../drivers/pmc; ..; ../../../../../boards/sam3x_ek; ../../../../../utils/cmsis/sam3x/source/templates; ../../../../../../common/services/serial; ../../../../../utils/cmsis/sam3x/include; ../../../../../../common/utils; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../drivers/can; ../../..; ../../../../../../common/services/gpio; ../../../../../drivers/uart; ../../../../../utils; ../../../../../drivers/usart; ../../../../../utils/header_files; ../../../../../../common/boards; ../..; ../../../../../drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM3X_EK; __SAM3X8H__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: can_can_example_flash.bin
  ILINK.IlinkOutputFile: can_can_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam3x
    ../../../../../../common/services/clock/sam3x/: sysclk.c
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/can
    ../../../../../drivers/can/: can.c
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c
  group sam/drivers/usart
    ../../../../../drivers/usart/: usart.c
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../utils/cmsis/sam3x/source/templates/: system_sam3x.c exceptions.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/boards/sam3x_ek
    ../../../../../boards/sam3x_ek/: init.c led.c
  group sam/components/can
    ../../../: sn65hvd234.c
  group sam/components/can/can_example
    ../../: can_example.c
