# IAR project ili9325_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3S4C__; BOARD=SAM3S_EK
  ICCARM.CCIncludePath2: ../../../../../../../common/services/serial; ../../../../../../utils/preprocessor; ../../../../../../drivers/pio; ../..; ..; ../../../../../../utils/cmsis/sam3s/include; ../../../../../../../common/utils; ../../../../../../utils/cmsis/sam3s/source/templates; ../../../../../../boards/sam3s_ek; ../../../../../../../common/services/clock; ../../../../../../boards; ../../../../aat31xx; ../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../drivers/ebi/smc; ../../../../../../../common/services/gpio; ../../../../../../../common/services/serial/sam_uart; ../../../../../../drivers/uart; ../../../../../../utils; ../../../../../../drivers/usart; ../../../../../../utils/header_files; ../../../../../../../common/boards; ../../..; ../../../../../../drivers/pmc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3S4C__; BOARD=SAM3S_EK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ili9325_example_flash.bin
  ILINK.IlinkOutputFile: ili9325_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/sam3s/sam3s4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/clock/sam3s
    ../../../../../../../common/services/clock/sam3s/: sysclk.c
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group sam/drivers/pio
    ../../../../../../drivers/pio/: pio.c pio_handler.c
  group sam/drivers/pmc
    ../../../../../../drivers/pmc/: sleep.c pmc.c
  group sam/drivers/ebi/smc
    ../../../../../../drivers/ebi/smc/: smc.c
  group sam/drivers/usart
    ../../../../../../drivers/usart/: usart.c
  group sam/drivers/uart
    ../../../../../../drivers/uart/: uart.c
  group sam/components/display/ili9325
    ../../../: ili9325.c
  group sam/components/display/ili9325/example
    ../../: ili9325_example.c
  group sam/components/display/aat31xx
    ../../../../aat31xx/: aat31xx.c
  group sam/utils/cmsis/sam3s/source/templates
    ../../../../../../utils/cmsis/sam3s/source/templates/: system_sam3s.c exceptions.c
  group sam/utils/cmsis/sam3s/source/templates/iar
    ../../../../../../utils/cmsis/sam3s/source/templates/iar/: startup_sam3s.c
  group sam/boards/sam3s_ek
    ../../../../../../boards/sam3s_ek/: init.c led.c
