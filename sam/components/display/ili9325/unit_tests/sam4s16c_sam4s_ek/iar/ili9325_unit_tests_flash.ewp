# IAR project ili9325_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; BOARD=SAM4S_EK; TEST_SUITE_DEFINE_ASSERT_MACRO; ARM_MATH_CM4=true; __SAM4S16C__
  ICCARM.CCIncludePath2: ../../../../../../../common/services/serial/sam_uart; ..; ../../../../../../utils/preprocessor; ../../../../../../drivers/pmc; ../../../../../../utils/cmsis/sam4s/include; ../../../../../../drivers/ebi/smc; ../../../../../../../common/services/serial; ../..; ../../../../../../../common/utils; ../../../../../../boards/sam4s_ek; ../../../../../../../common/services/clock; ../../../../../../boards; ../../../../aat31xx; ../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../common/services/gpio; ../../../../../../utils/cmsis/sam4s/source/templates; ../../../../../../drivers/uart; ../../../../../../utils; ../../../../../../drivers/usart; ../../../../../../utils/header_files; ../../../../../../../common/boards; ../../..; ../../../../../../drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ili9325_unit_tests_flash.bin
  ILINK.IlinkOutputFile: ili9325_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../utils/cmsis/sam4s/source/templates/: exceptions.c system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/drivers/pmc
    ../../../../../../drivers/pmc/: sleep.c pmc.c
  group sam/drivers/pio
    ../../../../../../drivers/pio/: pio.c pio_handler.c
  group sam/drivers/ebi/smc
    ../../../../../../drivers/ebi/smc/: smc.c
  group sam/drivers/usart
    ../../../../../../drivers/usart/: usart.c
  group sam/drivers/uart
    ../../../../../../drivers/uart/: uart.c
  group sam/components/display/ili9325
    ../../../: ili9325.c
  group sam/components/display/ili9325/unit_tests
    ../../: unit_tests.c
  group sam/components/display/aat31xx
    ../../../../aat31xx/: aat31xx.c
  group sam/boards/sam4s_ek
    ../../../../../../boards/sam4s_ek/: led.c init.c
  group common/utils/unit_test
    ../../../../../../../common/utils/unit_test/: suite.c
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
  group common/services/clock/sam4s
    ../../../../../../../common/services/clock/sam4s/: sysclk.c
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c
