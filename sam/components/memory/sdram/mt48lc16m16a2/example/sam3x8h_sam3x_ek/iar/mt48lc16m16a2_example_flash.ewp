# IAR project mt48lc16m16a2_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3X_EK; __SAM3X8H__
  ICCARM.CCIncludePath2: ../../../../../../../../common/services/serial/sam_uart; ../../../../../../../utils/preprocessor; ../../../../../../../drivers/pmc; ../../../../../../../boards/sam3x_ek; ../../../../../../../utils/cmsis/sam3x/source/templates; ../../../../../../../../common/services/gpio; ../../../../../../../../common/services/serial; ../../../../../../../utils/cmsis/sam3x/include; ../../..; ../../../../../../../../common/services/sleepmgr; ../../../../../../../../common/utils; ../../../../../../../../common/services/clock; ../../../../../../../boards; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../drivers/sdramc; ../..; ../../../../../../../drivers/uart; ../../../../../../../utils; ../../../../../../../drivers/usart; ../../../../../../../utils/header_files; ../../../../../../../../common/boards; ../../../../../../../drivers/pio; ..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM3X_EK; __SAM3X8H__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mt48lc16m16a2_example_flash.bin
  ILINK.IlinkOutputFile: mt48lc16m16a2_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../../utils/cmsis/sam3x/source/templates/: system_sam3x.c exceptions.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../../utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/drivers/usart
    ../../../../../../../drivers/usart/: usart.c
  group sam/drivers/pio
    ../../../../../../../drivers/pio/: pio.c pio_handler.c
  group sam/drivers/sdramc
    ../../../../../../../drivers/sdramc/: sdramc.c
  group sam/drivers/uart
    ../../../../../../../drivers/uart/: uart.c
  group sam/drivers/pmc
    ../../../../../../../drivers/pmc/: pmc.c sleep.c
  group sam/boards/sam3x_ek
    ../../../../../../../boards/sam3x_ek/: led.c init.c
  group sam/components/memory/sdram/mt48lc16m16a2/example
    ../../: mt48c16m16a2_example.c
  group common/services/sleepmgr/sam
    ../../../../../../../../common/services/sleepmgr/sam/: sleepmgr.c
  group common/services/clock/sam3x
    ../../../../../../../../common/services/clock/sam3x/: sysclk.c
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
