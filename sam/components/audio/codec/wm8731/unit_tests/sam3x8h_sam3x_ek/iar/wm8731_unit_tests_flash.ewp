# IAR project wm8731_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM3X_EK; __SAM3X8H__
  ICCARM.CCIncludePath2: ../../../../../../../utils/header_files; ../../../../../../../drivers/dmac; ../../../../../../../drivers/pmc; ../../../../../../../boards/sam3x_ek; ../../../../../../../utils/cmsis/sam3x/source/templates; ../..; ../../../../../../../../common/services/gpio; ../../../../../../../../common/services/serial; ../../../../../../../utils/cmsis/sam3x/include; ../../../../../../../../common/utils; ../../../../../../../../common/services/clock; ../../../../../../../boards; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../utils/preprocessor; ../../../../../../../../common/services/twi; ../../../../../../../drivers/uart; ../../../../../../../utils; ../../../../../../../drivers/usart; ../../../../../../../../common/services/serial/sam_uart; ../../../../../../../../common/boards; ../../..; ../../../../../../../drivers/pio; ../../../../../../../drivers/ssc; ..; ../../../../../../../drivers/twi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: wm8731_unit_tests_flash.bin
  ILINK.IlinkOutputFile: wm8731_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../../../../drivers/pio/: pio.c pio_handler.c
  group sam/drivers/ssc
    ../../../../../../../drivers/ssc/: ssc.c
  group sam/drivers/uart
    ../../../../../../../drivers/uart/: uart.c
  group sam/drivers/pmc
    ../../../../../../../drivers/pmc/: pmc.c sleep.c
  group sam/drivers/dmac
    ../../../../../../../drivers/dmac/: dmac.c
  group sam/drivers/twi
    ../../../../../../../drivers/twi/: twi.c
  group sam/drivers/usart
    ../../../../../../../drivers/usart/: usart.c
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../../utils/cmsis/sam3x/source/templates/: system_sam3x.c exceptions.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../../utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/components/audio/codec/wm8731
    ../../../: wm8731.c
  group sam/components/audio/codec/wm8731/unit_tests
    ../../: unit_tests.c
  group sam/boards/sam3x_ek
    ../../../../../../../boards/sam3x_ek/: led.c init.c
  group common/utils/unit_test
    ../../../../../../../../common/utils/unit_test/: suite.c
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: read.c write.c
  group common/services/clock/sam3x
    ../../../../../../../../common/services/clock/sam3x/: sysclk.c
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c
